<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>hw:1,0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ben/Desktop/senior_design/field_test/audio_recordings/drum</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>200</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>200</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0.01371777057647705,0.3173022270202637,0.4519832134246826,0.3639616966247559,0.2825771570205688,0.2426620721817017,0.2354069948196411,0.1919393539428711,0.1701457500457764,0.05869114398956299,-0.1433526277542114,-0.1665060520172119,0.2600053548812866,0.9259870052337646,1.374908089637756,1.510873913764954,1.398687720298767,1.148596286773682,0.9998834133148193,1.08217179775238,1.235282301902771,1.291973233222961,1.226245880126953,1.055084824562073,0.8617633581161499,0.7524021863937378,0.6743736267089844,0.5853854417800903,0.5325165987014771,0.5058045387268066,0.4311380386352539,0.3283064365386963,0.3285759687423706,0.5017858743667603,0.6736663579940796,0.7228164672851562,0.6178184747695923,0.5011110305786133,0.5017108917236328,0.6053166389465332,0.7181878089904785,0.8713388442993164,1.120171785354614,1.252613425254822,1.147224307060242,0.9579174518585205,0.8324025869369507,0.7498548030853271,0.5523079633712769,0.3701224327087402,0.2976000308990479,0.3533263206481934,0.5906950235366821,0.8721251487731934,0.957568883895874,0.9370135068893433,1.12015962600708,1.481207132339478,1.770871162414551,1.833807945251465,1.688185572624207,1.409158945083618,1.201151013374329,1.275185227394104,1.550140500068665,1.771242022514343,1.85822594165802,1.839004039764404,1.734316110610962,1.623410701751709,1.60030996799469,1.620279669761658,1.615819215774536,1.684937000274658,1.941426277160645,2.186957955360413,2.092842578887939,1.744471192359924,1.450887799263,1.396900296211243,1.293868064880371,0.9974515438079834,0.6928132772445679,0.5619462728500366,0.5621428489685059,0.6877428293228149,0.9361968040466309,1.104624032974243,1.082163691520691,1.046694874763489,1.104326128959656,1.12409520149231,1.035664319992065,0.9365088939666748,0.8438931703567505,0.658696174621582,0.4720157384872437,0.3234062194824219,0.08994472026824951,-0.1060963869094849,-0.03301465511322021,0.1904153823852539,0.3784819841384888,0.5693979263305664,0.7399733066558838,0.658696174621582,0.2852582931518555,-0.06852400302886963,-0.2012594938278198,-0.311753511428833,-0.5460114479064941,-0.6174476146697998,-0.2839673757553101,0.199626088142395,0.5129643678665161,0.613465428352356,0.5025883913040161,0.2860628366470337,0.1663662195205688,0.121739387512207,-0.03411710262298584,-0.4166157245635986,-0.7471898794174194,-0.7426828145980835,-0.4305341243743896,-0.1146119832992554,-0.07086062431335449,-0.3120737075805664,-0.4136042594909668,-0.1453629732131958,0.2258517742156982,0.3581252098083496,0.1633689403533936,-0.1923041343688965,-0.3739161491394043,-0.3005466461181641,-0.1479448080062866,-0.02142477035522461,-0.03198516368865967,-0.2077910900115967,-0.3694840669631958,-0.3304890394210815,-0.248119592666626,-0.4428616762161255,-0.7621479034423828,-0.8601704835891724,-0.7834895849227905,-0.7550731897354126,-0.7971566915512085,-0.7808915376663208,-0.6637605428695679,-0.6751153469085693,-0.7912452220916748,-0.7961089611053467,-0.7550286054611206,-0.8081507682800293,-0.9436748027801514,-0.9184117317199707,-0.6126081943511963,-0.4063431024551392,-0.6211643218994141,-1.053654074668884,-1.354859352111816,-1.385018587112427,-1.126672983169556,-0.7018091678619385,-0.4418483972549438,-0.5342797040939331,-0.8938944339752197,-1.174222111701965,-1.187279224395752,-1.066269397735596,-1.061770439147949,-1.13301408290863,-1.038685917854309,-0.7804416418075562,-0.5717507600784302,-0.5951980352401733,-0.7421133518218994,-0.7756204605102539,-0.6891168355941772,-0.7049523591995239,-0.6712466478347778,-0.3978943824768066,0.07358837127685547,0.3826344013214111,0.2971866130828857,0.0002675056457519531,-0.1956135034561157,-0.2360656261444092,-0.2264941930770874,-0.1148409843444824,0.04985535144805908,-0.01074278354644775,-0.3668049573898315,-0.6648913621902466,-0.5996909141540527,-0.4393922090530396,-0.4370819330215454,-0.4870730638504028,-0.414720892906189,-0.1976765394210815,0.07533526420593262,0.348432183265686,0.5702348947525024,0.6915932893753052,0.6885615587234497,0.5692965984344482,0.4251211881637573,0.3623019456863403,0.4602292776107788,0.7924854755401611,1.142364621162415,1.307924270629883,1.309843420982361,1.292771697044373,1.229796409606934,1.140212416648865,1.028313994407654,0.9208152294158936,0.8620409965515137,0.8624645471572876,0.8763586282730103,0.877740740776062,0.951772928237915,1.152937173843384,1.215640902519226,0.9314749240875244,0.5550113916397095,0.3422086238861084,0.2609416246414185,0.3556102514266968,0.6684560775756836,1.103136539459229,1.308137059211731,1.121166825294495,0.8036011457443237,0.6854467391967773,0.735812783241272,0.7645899057388306,0.6957659721374512,0.6221228837966919,0.7497777938842773,1.030636429786682,1.208860039710999,1.181284666061401,1.09948468208313,1.104919910430908,1.293720126152039,1.614473581314087,1.918153285980225,1.987992525100708,1.921166777610779,1.969937920570374,2.10673463344574,2.144762992858887,2.04477059841156,1.943262338638306,1.823115825653076,1.632641673088074,1.460684180259705,1.326207876205444,1.312224626541138,1.454713940620422,1.662397623062134,1.822363972663879,1.916615128517151,1.79071319103241,1.390660524368286,0.9179760217666626,0.5664938688278198,0.2626054286956787,-0.1030241250991821,-0.3973816633224487,-0.3983868360519409,-0.1388030052185059,0.01450204849243164,0.01379883289337158,-0.06320631504058838,-0.3792034387588501,-0.9345552921295166,-1.370713114738464,-1.619177222251892,-1.754095315933228,-1.700217247009277,-1.422781467437744,-1.205299377441406,-1.067306995391846,-1.033864736557007,-1.213859558105469,-1.534677863121033,-1.736504793167114,-1.765304207801819,-1.689198851585388,-1.497863411903381,-1.224128127098083,-0.9550539255142212,-0.9191676378250122,-1.172683954238892,-1.417208433151245,-1.461338758468628,-1.462704658508301,-1.457089066505432,-1.182154059410095,-0.6716600656509399,-0.3369699716567993,-0.3086508512496948,-0.3446850776672363,-0.4733755588531494,-0.7830437421798706,-0.9444854259490967,-0.7617020606994629,-0.4296464920043945,-0.3149129152297974,-0.3309794664382935,-0.2484134435653687,-0.2299981117248535,-0.415831446647644,-0.5977697372436523,-0.6236063241958618,-0.5878781080245972,-0.5223209857940674,-0.4048697948455811,-0.3412176370620728,-0.4054291248321533,-0.5806676149368286,-0.8020001649856567,-0.9355199337005615,-0.8989405632019043,-0.6814726591110229,-0.2950303554534912,0.09350943565368652,0.269005298614502,0.2319618463516235,0.04452550411224365,-0.1243435144424438,-0.2153035402297974,-0.2600175142288208,-0.3017828464508057,-0.3371624946594238,-0.4088519811630249,-0.5058876276016235,-0.5687656402587891,-0.7076780796051025,-0.9140059947967529,-0.9936517477035522,-0.8754446506500244,-0.7175190448760986,-0.6580193042755127,-0.6460970640182495,-0.6342538595199585,-0.6035839319229126,-0.5292903184890747,-0.4052163362503052,-0.2382684946060181,-0.06489443778991699,-0.05425500869750977,-0.2450757026672363,-0.4866616725921631,-0.6798534393310547,-0.8464608192443848,-0.9519715309143066,-0.9353091716766357,-0.8003566265106201,-0.7606745958328247,-0.9444246292114258,-1.268286824226379,-1.475326061248779,-1.422327518463135,-1.354820847511292,-1.497328400611877,-1.657187342643738,-1.572465062141418,-1.322582364082336,-1.089917302131653,-0.9785498380661011,-0.8647525310516357,-0.639656662940979,-0.4440208673477173,-0.4015442132949829,-0.4687225818634033,-0.5026735067367554,-0.4425374269485474,-0.1753904819488525,0.2517714500427246,0.6400903463363647,0.752509593963623,0.627612829208374,0.468904972076416,0.4149519205093384,0.5206450223922729,0.583893895149231,0.5785235166549683,0.6700489521026611,0.924700140953064,1.230919122695923,1.405640840530396,1.381127595901489,1.32949697971344,1.430999159812927,1.670210003852844,1.863116025924683,1.910389542579651,1.854227542877197,1.771002888679504,1.768998622894287,1.860418677330017,1.887649536132812,1.774958729743958,1.58069896697998,1.406958103179932,1.383458137512207,1.518459320068359,1.644957065582275,1.681572914123535,1.711357235908508,1.642117857933044,1.399848937988281,1.253458499908447,1.38178014755249,1.630552291870117,1.689529180526733,1.541037201881409,1.289851427078247,0.9734145402908325,0.5816606283187866,0.2438070774078369,0.128187894821167,0.2075722217559814,0.2596648931503296,0.2637099027633667,0.2059469223022461,0.02792191505432129,-0.10294508934021,-0.1910719871520996,-0.2849137783050537,-0.4395543336868286,-0.5575222969055176,-0.6892890930175781,-0.8898048400878906,-1.120149493217468,-1.218245029449463,-1.147007465362549,-1.092405915260315,-1.195794820785522,-1.299033761024475,-1.272408843040466,-1.236611723899841,-1.350423216819763,-1.460716605186462,-1.493281364440918,-1.50952422618866,-1.530416011810303,-1.493508338928223,-1.301935791969299,-0.9931491613388062,-0.724695086479187,-0.5676449537277222,-0.6034501791000366,-0.8883477449417114,-1.201882600784302,-1.224531412124634,-1.090644836425781,-1.052298307418823,-0.9538420438766479,-0.6761752367019653,-0.5267267227172852,-0.6210163831710815,-0.8699283599853516,-1.06679630279541,-1.189125418663025,-1.199120402336121,-1.090656995773315,-0.8359267711639404,-0.5363245010375977,-0.3351460695266724,-0.363359808921814,-0.5234842300415039,-0.5995227098464966,-0.5390137434005737,-0.5752972364425659,-0.8283616304397583,-1.095413327217102,-1.152614951133728,-0.8989567756652832,-0.4157868623733521,0.04084932804107666,0.2156602144241333,0.04083108901977539,-0.3162382841110229,-0.5537265539169312,-0.4849086999893188,-0.229604959487915,-0.06588137149810791,0.01647591590881348,0.1414233446121216,0.313917875289917,0.4440938234329224,0.4024379253387451,0.1736760139465332,-0.203391432762146,-0.5707557201385498,-0.7453274726867676,-0.6976121664047241,-0.6060826778411865,-0.5866479873657227,-0.6172510385513306,-0.5769002437591553,-0.5231761932373047,-0.6476960182189941,-0.9816626310348511,-1.261548519134521,-1.273371458053589,-1.055151700973511,-0.7402448654174805,-0.4000546932220459,-0.2426803112030029,-0.3266487121582031,-0.5396561622619629,-0.7938169240951538,-1.044392704963684,-1.182220935821533,-1.182881593704224,-1.006398797035217,-0.7498608827590942,-0.5871059894561768,-0.5599967241287231,-0.6062711477279663,-0.6721444129943848,-0.6852927207946777,-0.6129506826400757,-0.5603412389755249,-0.5921136140823364,-0.5818065404891968,-0.4117803573608398,-0.1263457536697388,0.1053931713104248,0.2251262664794922,0.3463914394378662,0.5564684867858887,0.7679499387741089,0.8452306985855103,0.6467901468276978,0.3608570098876953,0.3107746839523315,0.5751209259033203,0.7954341173171997,0.8830665349960327,0.8811331987380981,0.6975919008255005,0.2956950664520264,-0.04178357124328613,-0.04284548759460449,0.01633608341217041,-0.1446212530136108,-0.3831775188446045,-0.40870201587677,-0.3070214986801147,-0.3318731784820557,-0.5204160213470459,-0.6409637928009033,-0.6581976413726807,-0.6493699550628662,-0.560799241065979,-0.3021597862243652,-0.04626429080963135,0.05701720714569092,0.03760480880737305,-0.1118862628936768,-0.5447124242782593,-1.201635360717773,-1.703157782554626,-1.738985300064087,-1.401551246643066,-1.101825356483459,-1.076049566268921,-1.252141237258911,-1.51818573474884,-1.708493709564209,-1.644740223884583,-1.474260091781616,-1.464210391044617,-1.52552592754364,-1.440653681755066,-1.345539212226868,-1.448054671287537,-1.592748880386353,-1.572053670883179,-1.398817420005798,-1.215831398963928,-1.04486083984375,-0.8019778728485107,-0.5059707164764404,-0.3901265859603882,-0.4090789556503296,-0.3803788423538208,-0.3244032859802246,-0.3554359674453735,-0.3577584028244019,-0.3002203702926636,-0.3279234170913696,-0.4566159248352051,-0.6200598478317261,-0.7636009454727173,-0.7092912197113037,-0.4760202169418335,-0.2487843036651611,-0.1734308004379272,-0.1136655807495117,-0.100847601890564,-0.3108577728271484,-0.6808606386184692,-0.9612551927566528,-0.9892966747283936,-0.8204823732376099,-0.5320788621902466,-0.2745661735534668,-0.1020007133483887,-0.009994983673095703,0.07675588130950928,0.09959518909454346,-0.06894350051879883,-0.3551198244094849,-0.5253770351409912,-0.4097497463226318,-0.0899507999420166,0.2702354192733765,0.5181868076324463,0.5176436901092529,0.2020235061645508,-0.2558711767196655,-0.5335785150527954,-0.522904634475708,-0.4434797763824463,-0.3926172256469727,-0.2642874717712402,0.001086235046386719,0.2653210163116455,0.3188647031784058,0.1667107343673706,-0.07143616676330566,-0.2901706695556641,-0.4183099269866943,-0.2854751348495483,0.0639338493347168,0.3853216171264648,0.4072428941726685,0.1136432886123657,-0.2205320596694946,-0.5100765228271484,-0.6603538990020752,-0.7454673051834106,-0.7338956594467163,-0.5882611274719238,-0.4327329397201538,-0.3683755397796631,-0.4048556089401245,-0.4844770431518555,-0.6605403423309326,-0.9587260484695435,-1.071882963180542,-0.7509430646896362,-0.1645017862319946,0.2605180740356445,0.3668434619903564,0.239662766456604,0.08695352077484131,0.02652156352996826,0.1441024541854858,0.3569457530975342,0.4740970134735107,0.4026608467102051,0.1968010663986206,0.06964671611785889,0.1109216213226318,0.2706427574157715,0.3299601078033447,0.2226903438568115,0.1185394525527954,0.1960816383361816,0.3397078514099121,0.3476904630661011,0.2100344896316528,0.1294747591018677,0.1909382343292236,0.3231934309005737,0.3803991079330444,0.2073513269424438,-0.06959807872772217,-0.2210447788238525,-0.1971151828765869,-0.1458290815353394,-0.08311724662780762,0.07478809356689453,0.3157316446304321,0.4591329097747803,0.4064079523086548,0.2556746006011963,0.2158061265945435,0.153927206993103,-0.1179618835449219,-0.5239949226379395,-0.7031345367431641,-0.5260154008865356,-0.1550924777984619,0.08143115043640137,0.02379179000854492,-0.2753058671951294,-0.6591298580169678,-1.056193351745605,-1.314184308052063,-1.334117531776428,-1.079464316368103,-0.7169110774993896,-0.5499875545501709,-0.736738920211792,-1.037084937095642,-1.272143363952637,-1.472989439964294,-1.637529730796814,-1.713529706001282,-1.656028151512146,-1.575097560882568,-1.509167551994324,-1.36625874042511,-1.297917127609253,-1.4925457239151,-1.778659224510193,-1.820783257484436,-1.696012139320374,-1.811493515968323,-2.059159159660339,-2.016404867172241,-1.688655734062195,-1.36173951625824,-1.067787289619446,-0.7815217971801758,-0.7377218008041382,-0.9618793725967407,-1.013787627220154,-0.7900536060333252,-0.6212007999420166,-0.6809498071670532,-0.7102396488189697,-0.550222635269165,-0.4493973255157471,-0.6133397817611694,-0.9380977153778076,-1.171723365783691,-1.243159532546997,-1.159539699554443,-0.8069591522216797,-0.2924343347549438,-0.0009464025497436523,-0.111268162727356,-0.3618297576904297,-0.5585112571716309,-0.7068390846252441,-0.8887875080108643,-1.020872473716736,-0.9308466911315918,-0.6193850040435791,-0.3775761127471924,-0.2716175317764282,-0.3165280818939209,-0.5900667905807495,-1.086774110794067,-1.507623314857483,-1.761346340179443,-1.972781181335449,-2.249730587005615,-2.45747709274292,-2.250764131546021,-1.589328050613403,-0.9467653036117554,-0.8731039762496948,-1.319911360740662,-1.700148344039917,-1.680640697479248,-1.388558983802795,-1.140929818153381,-1.08773672580719,-1.133232951164246,-1.125432729721069,-1.071467518806458,-0.8998585939407349,-0.6250512599945068,-0.5616301298141479,-0.8129557371139526,-0.9721945524215698,-0.9001585245132446,-0.8706275224685669,-1.011063933372498,-1.110347032546997,-0.9836405515670776,-0.73762047290802,-0.635350227355957,-0.6160715818405151,-0.6620622873306274,-0.7879034280776978,-0.9099447727203369,-0.843951940536499,-0.6363351345062256,-0.4500478506088257,-0.4257473945617676,-0.4674316644668579,-0.4114277362823486,-0.2786476612091064,-0.2464760541915894,-0.3574604988098145,-0.4735863208770752,-0.4620106220245361,-0.2946898937225342,-0.08704268932342529,0.1342169046401978,0.20751953125,-0.03425693511962891,-0.3972377777099609,-0.6043378114700317,-0.5851483345031738,-0.4032039642333984,-0.2061779499053955,-0.1225824356079102,-0.2889121770858765,-0.5979136228561401,-0.7820851802825928,-0.7698812484741211,-0.6326123476028442,-0.2971481084823608,0.3489793539047241,1.035490036010742,1.359611630439758,1.291130185127258,1.150059461593628,1.107027530670166,1.088942527770996,0.9994416236877441,0.9414759874343872,0.9610586166381836,0.9799826145172119,0.9361279010772705,0.8128523826599121,0.5177693367004395,0.1346708536148071,-0.02729165554046631,0.1623029708862305,0.5246920585632324,0.8295410871505737,0.936654806137085,0.9055978059768677,0.9148247241973877,0.9292740821838379,0.7800302505493164,0.5369912385940552,0.400875449180603,0.4739348888397217,0.7759852409362793,1.068555355072021,1.107586860656738,0.9613504409790039,0.8521838188171387,0.8027459383010864,0.7432765960693359,0.761937141418457,0.8895697593688965,1.020011186599731,0.960519552230835,0.7308193445205688,0.3278464078903198,-0.1408538818359375,-0.4927940368652344,-0.4762451648712158,-0.0473930835723877,0.4814838171005249,0.8096686601638794,0.7436211109161377,0.4110589027404785,0.156833291053772,0.2015756368637085,0.4396333694458008,0.6400113105773926,0.8016718626022339,1.045391798019409,1.066360592842102,0.7098850011825562,0.3683755397796631,0.3520820140838623,0.3922483921051025,0.2027976512908936,0.03070235252380371,0.04111683368682861,0.03842556476593018,-0.08458244800567627,-0.1653387546539307,-0.1184523105621338,-0.1236869096755981,-0.1765213012695312,-0.08137643337249756,0.07231974601745605,-0.05508792400360107,-0.4775117635726929,-0.84482741355896,-0.998665452003479,-1.112545847892761,-1.253438234329224,-1.310449361801147,-1.202287912368774,-1.063851714134216,-0.8810359239578247,-0.6892445087432861,-0.6856230497360229,-0.8681713342666626,-1.012857437133789,-0.9608883857727051,-0.7437001466751099,-0.5694952011108398,-0.5439767837524414,-0.6544181108474731,-0.755689263343811,-0.7577219009399414,-0.8032140731811523,-1.120139360427856,-1.4322110414505,-1.383705377578735,-1.084287524223328,-0.7305943965911865,-0.4662826061248779,-0.3974688053131104,-0.7375252246856689,-1.253377437591553,-1.536471366882324,-1.497920155525208,-1.499515056610107,-1.675458788871765,-1.965420722961426,-2.331179976463318,-2.664698719978333,-2.899053931236267,-2.879136919975281,-2.620841979980469,-2.28204607963562,-2.006967186927795,-1.84170138835907,-1.879770278930664,-2.253544569015503,-2.775784492492676,-2.94611668586731,-2.804354906082153,-2.727169394493103,-2.796096682548523,-2.757583975791931,-2.547042846679688,-2.287519812583923,-1.978660225868225,-1.714692950248718,-1.719161510467529,-2.012572646141052,-2.273929715156555,-2.315050601959229,-2.36223292350769,-2.534074902534485,-2.5448237657547,-2.28745698928833,-1.956412672996521,-1.750633955001831,-1.609350442886353,-1.520639896392822,-1.476779103279114,-1.381913900375366,-1.345646619796753,-1.578579187393188,-2.050902962684631,-2.453879952430725,-2.491677284240723,-2.075104117393494,-1.388279318809509,-0.9825745820999146,-1.071493864059448,-1.202893853187561,-1.017956256866455,-0.7746497392654419,-0.7481950521469116,-0.8915051221847534,-1.068044662475586,-1.171255230903625,-1.081067323684692,-0.7984516620635986,-0.461145281791687,-0.3272039890289307,-0.3479255437850952,-0.1248562335968018,0.3397078514099121,0.6303385496139526,0.5931532382965088,0.5490938425064087,0.6314288377761841,0.8639398813247681,1.36447536945343,1.938990354537964,2.131758570671082,1.956892967224121,1.820519804954529,1.813278913497925,1.790828704833984,1.873354196548462,2.197840571403503,2.605531334877014,2.884292483329773,3.033161401748657,3.188432216644287,3.334725379943848,3.383579611778259,3.413617253303528,3.453283071517944,3.407940864562988,3.182528853416443,2.951446533203125,2.835592269897461,2.945496559143066,3.134554147720337,3.221876502037048,3.185884833335876,3.082086563110352,3.024694442749023,3.253727912902832,3.637495160102844,3.872851490974426,3.785934448242188,3.551715016365051,3.308122754096985,3.106893658638,2.904479026794434,2.760668396949768,2.818101048469543,2.967962980270386,3.030926108360291,3.025910377502441,2.911065340042114,2.816641926765442,2.74778151512146,2.457539916038513,1.904589533805847,1.507169365882874,1.51652193069458,1.636561036109924,1.540143489837646,1.364459156990051,1.312394857406616,1.208440542221069,0.8493912220001221,0.4200750589370728,0.1566083431243896,-0.03783988952636719,-0.2268832921981812,-0.2920857667922974,-0.2450088262557983,-0.3117818832397461,-0.4271558523178101,-0.4275591373443604,-0.5587199926376343,-0.9922453165054321,-1.362698078155518,-1.476560235023499,-1.561529755592346,-1.788052320480347,-1.932900547981262,-1.891508102416992,-1.9028000831604,-1.964040637016296,-2.048671722412109,-2.149136304855347,-2.256432414054871,-2.289134979248047,-2.286715269088745,-2.462847471237183,-2.836931824684143,-2.985780477523804,-2.808497190475464,-2.664299488067627,-2.686200499534607,-2.720797896385193,-2.70824134349823,-2.772963523864746,-2.858705163002014,-2.834133148193359,-2.581101179122925,-2.234022736549377,-2.012074112892151,-1.975575804710388,-1.998960256576538,-2.040666818618774,-1.943623065948486,-1.650641560554504,-1.415645956993103,-1.351845860481262,-1.404335737228394,-1.552677750587463,-1.711345076560974,-1.739753365516663,-1.635869979858398,-1.514894604682922,-1.504297733306885,-1.512166857719421,-1.450831055641174,-1.370636105537415,-1.385511040687561,-1.339141368865967,-1.117038726806641,-0.9741400480270386,-1.098443031311035,-1.212787508964539,-1.09669816493988,-0.9325956106185913,-0.8388389348983765,-0.7314496040344238,-0.5990707874298096,-0.6155041456222534,-0.740644097328186,-0.7757197618484497,-0.6805019378662109,-0.5466052293777466,-0.4596983194351196,-0.4078346490859985,-0.3864058256149292,-0.3233150243759155,-0.2627189159393311,-0.1610039472579956,0.07213127613067627,0.2760556936264038,0.2306162118911743,0.04474234580993652,0.06597864627838135,0.3371908664703369,0.4845054149627686,0.3769681453704834,0.46473228931427,0.9104189872741699,1.247571349143982,1.048070907592773,0.4254474639892578,-0.1684130430221558,-0.3799329996109009,-0.3009722232818604,-0.1079446077346802,0.05318295955657959,0.1909139156341553,0.3971729278564453,0.6356278657913208,0.7892612218856812,0.6647109985351562,0.2484803199768066,-0.1482913494110107,-0.3554400205612183,-0.330201268196106,-0.09099853038787842,0.2948013544082642,0.6272217035293579,0.7653701305389404,0.6850616931915283,0.3648169040679932,-0.0151059627532959,-0.2925822734832764,-0.4089978933334351,-0.4065417051315308,-0.2929004430770874,-0.1390360593795776,-0.09025883674621582,-0.2138363122940063,-0.3779793977737427,-0.4712111949920654,-0.5288404226303101,-0.6012331247329712,-0.6399140357971191,-0.6080950498580933,-0.4951711893081665,-0.3395538330078125,-0.05356192588806152,0.3187674283981323,0.5961707830429077,0.6966272592544556,0.6689505577087402,0.4960993528366089,0.2930341958999634,0.2886325120925903,0.6618211269378662,1.121718049049377,1.146478533744812,0.7987779378890991,0.5987951755523682,0.6935164928436279,0.6766717433929443,0.462049126625061,0.3979713916778564,0.591386079788208,0.7480795383453369,0.8087445497512817,0.9373337030410767,1.114740610122681,1.216076612472534,1.116307139396667,0.8798990249633789,0.6895849704742432,0.490287184715271,0.2412576675415039,0.009287714958190918,-0.1913577318191528,-0.4129436016082764,-0.5231701135635376,-0.481037974357605,-0.3835686445236206,-0.184558629989624,0.01397919654846191,0.05456507205963135,-0.05512642860412598,-0.2805870771408081,-0.5923608541488647,-0.8031917810440063,-1.021002173423767,-1.384171485900879,-1.770155787467957,-2.061128973960876,-2.261286020278931,-2.32989513874054,-2.306038498878479,-2.324940204620361,-2.404549479484558,-2.327268719673157,-1.997918605804443,-1.594029664993286,-1.497926235198975,-1.722249984741211,-2.005704641342163,-2.00445830821991,-1.741698861122131,-1.403444051742554,-1.252990365028381,-1.265141606330872,-1.133101224899292,-0.8063998222351074,-0.531791090965271,-0.4699912071228027,-0.4935985803604126,-0.3680310249328613,-0.001078128814697266,0.658740758895874,1.360327005386353,1.677989959716797,1.513861060142517,1.125205755233765,0.785327672958374,0.5823719501495361,0.3790109157562256,0.2041655778884888,0.3741573095321655,0.8513407707214355,1.329365253448486,1.747442126274109,2.102711915969849,2.055531620979309,1.696926116943359,1.481788754463196,1.582871437072754,1.790439605712891,2.00690233707428,2.095967531204224,1.926040649414062,1.611081123352051,1.366554617881775,1.234722971916199,1.033889055252075,0.8379391431808472,0.6573829650878906,0.4775482416152954,0.3771262168884277,0.3699420690536499,0.3554602861404419,0.4554243087768555,0.8008105754852295,1.1825350522995,1.198984622955322,0.9180388450622559,0.8423185348510742,1.164083242416382,1.470581889152527,1.449949502944946,1.223366141319275,1.077376961708069,1.132448673248291,1.253961086273193,1.184127926826477,0.9245927333831787,0.6480770111083984,0.5108993053436279,0.6647515296936035,1.063136339187622,1.331008791923523,1.182591795921326,0.8687468767166138,0.6899598836898804,0.5904092788696289,0.3753246068954468,0.1608175039291382,0.06464517116546631,-0.02929186820983887,-0.2671773433685303,-0.4315048456192017,-0.3840408325195312,-0.2858561277389526,-0.3313219547271729,-0.4710632562637329,-0.5204828977584839,-0.5548796653747559,-0.6156095266342163,-0.6638963222503662,-0.7625025510787964,-1.025910496711731,-1.345743894577026,-1.439934253692627,-1.296273589134216,-1.322817444801331,-1.555800676345825,-1.490233421325684,-0.9974150657653809,-0.5177288055419922,-0.376285195350647,-0.2922478914260864,-0.2699192762374878,-0.4545853137969971,-0.7022590637207031,-0.6622872352600098,-0.4389808177947998,-0.4398785829544067,-0.7347731590270996,-1.008494257926941,-1.19297182559967,-1.384122848510742,-1.593559503555298,-1.653764486312866,-1.560149669647217,-1.538439154624939,-1.786141276359558,-2.122472882270813,-2.315774083137512,-2.369443416595459,-2.348239541053772,-2.298414587974548,-2.240114569664001,-2.322810292243958,-2.482669234275818,-2.518056988716125,-2.452984213829041,-2.414526224136353,-2.38132107257843,-2.318280935287476,-2.369011759757996,-2.541680574417114,-2.515353560447693,-2.32603657245636,-2.324129581451416,-2.649037480354309,-2.917199730873108,-2.974231123924255,-2.910291194915771,-2.806940793991089,-2.689984083175659,-2.595544457435608,-2.363327264785767,-1.904303789138794,-1.395023703575134,-1.177371382713318,-1.331154704093933,-1.513494253158569,-1.448780179023743,-1.152669668197632,-0.8319486379623413,-0.7760237455368042,-0.8562126159667969,-0.7466589212417603,-0.4788432121276855,-0.3892166614532471,-0.5566427707672119,-0.7790250778198242,-0.7214951515197754,-0.3731521368026733,0.00402677059173584,0.3766803741455078,0.7620242834091187,0.953078031539917,0.7388161420822144,0.4750089645385742,0.5541318655014038,0.7883411645889282,0.7076051235198975,0.5923993587493896,0.8742368221282959,1.208010911941528,1.214236497879028,1.033048033714294,0.8905384540557861,0.9323889017105103,1.236394882202148,1.756271839141846,2.244299411773682,2.522278308868408,2.571693897247314,2.538259744644165,2.541457653045654,2.5836181640625,2.459736704826355,2.146011352539062,1.969554901123047,2.183145999908447,2.605610370635986,2.994160294532776,3.173571467399597,3.021022319793701,2.758153438568115,2.683997631072998,2.749443292617798,2.869901895523071,3.013937473297119,3.246728181838989,3.538907170295715,3.926322221755981,4.086746573448181,3.678322196006775,2.943976640701294,2.559947967529297,2.646652221679688,2.775981068611145,2.643476605415344,2.452491760253906,2.531685590744019,2.623711585998535,2.349094748497009,1.8151615858078,1.450478434562683,1.148973226547241,0.6708859205245972,0.2851063013076782,0.4942126274108887,1.007322907447815,1.002349734306335,0.3336241245269775,-0.336137056350708,-0.6054929494857788,-0.6761245727539062,-0.7462880611419678,-0.7706229686737061,-0.8043813705444336,-0.9653650522232056,-1.159487009048462,-1.10904598236084,-0.748871922492981,-0.4420003890991211,-0.4405210018157959,-0.4279117584228516,-0.1459243297576904,0.1898337602615356,0.2259997129440308,0.04073178768157959,-0.08407580852508545,-0.2509790658950806,-0.5791031122207642,-0.8138048648834229,-0.5756518840789795,0.01975488662719727,0.5604648590087891,0.9269678592681885,1.096714377403259,0.9689520597457886,0.7758737802505493,0.7048368453979492,0.7654126882553101,0.8627908229827881,0.7843812704086304,0.4793093204498291,0.2593669891357422,0.3688943386077881,0.5081026554107666,0.2112200260162354,-0.4229608774185181,-0.9116045236587524,-1.000361680984497,-0.7794040441513062,-0.6146388053894043,-0.7680654525756836,-1.109546542167664,-1.523523688316345,-1.933380842208862,-2.030023336410522,-1.679104566574097,-1.404947757720947,-1.462054133415222,-1.507607102394104,-1.307443976402283,-1.175231337547302,-1.254119157791138,-1.328816056251526,-1.281062245368958,-1.146186709403992,-1.158303499221802,-1.403855443000793,-1.697714447975159,-1.920737147331238,-2.245981454849243,-2.590873241424561,-2.819647312164307,-2.884661316871643,-2.685635089874268,-2.224704623222351,-1.770220637321472,-1.452853560447693,-1.165094494819641,-0.7720354795455933,-0.4849978685379028,-0.5565758943557739,-0.881980299949646,-1.120327830314636,-1.076704144477844,-0.8474984169006348,-0.7234669923782349,-0.7354094982147217,-0.7897313833236694,-0.8414876461029053,-0.9926891326904297,-1.230827927589417,-1.300336837768555,-1.010289788246155,-0.6678359508514404,-0.6568175554275513,-0.6838538646697998,-0.437079906463623,-0.1969064474105835,-0.08776211738586426,0.1290897130966187,0.4595037698745728,0.5468240976333618,0.2358204126358032,-0.2938103675842285,-0.7420687675476074,-1.065367579460144,-1.111109018325806,-0.8612668514251709,-0.5726505517959595,-0.3352879285812378,-0.0003789663314819336,0.3607860803604126,0.4793518781661987,0.2547606229782104,0.009119510650634766,-0.01787221431732178,-0.08666980266571045,-0.3220767974853516,-0.4060735702514648,-0.4021542072296143,-0.5507981777191162,-0.5352686643600464,-0.07404839992523193,0.4729418754577637,0.7702865600585938,0.9452656507492065,0.9660013914108276,0.8486008644104004,0.7597200870513916,0.7373428344726562,0.6083666086196899,0.3085089921951294,0.1609958410263062,0.3480937480926514,0.5536637306213379,0.6733218431472778,0.8998038768768311,1.140666365623474,1.283944010734558,1.550517439842224,1.928598165512085,2.075225710868835,1.878906965255737,1.608371615409851,1.51096510887146,1.413992285728455,1.133153915405273,0.9209287166595459,0.8803712129592896,0.8861550092697144,0.8565834760665894,0.776323676109314,0.6047958135604858,0.3162423372268677,0.04986953735351562,-0.1452353000640869,-0.3022915124893188,-0.4319689273834229,-0.4201743602752686,-0.4603569507598877,-0.6159337759017944,-0.6169713735580444,-0.2825508117675781,0.2365033626556396,0.6334229707717896,0.8802638053894043,1.105185389518738,1.376952886581421,1.355357885360718,1.01191508769989,0.7845170497894287,0.7746254205703735,0.6169977188110352,0.3843792676925659,0.464910626411438,0.882906436920166,1.414559721946716,2.028989791870117,2.738388419151306,3.261799693107605,3.214868664741516,2.787196040153503,2.492554783821106,2.364326357841492,2.022101521492004,1.576773524284363,1.423796772956848,1.650378108024597,2.105903744697571,2.487245202064514,2.628666520118713,2.690968990325928,2.730865836143494,2.554010152816772,2.451855421066284,2.524430513381958,2.215226411819458,1.518120884895325,1.084103107452393,1.182474255561829,1.650872588157654,2.123595595359802,2.305995941162109,2.371204495429993,2.429847002029419,2.339507102966309,2.043637752532959,1.730050206184387,1.663662195205688,1.732220649719238,1.727020502090454,1.777080535888672,1.998638033866882,2.234460473060608,2.213183641433716,2.004630565643311,1.69977343082428,1.396002531051636,1.065333127975464,0.7557520866394043,0.7208871841430664,0.9225621223449707,0.9668951034545898,0.7468554973602295,0.7149878740310669,0.8913896083831787,0.8026142120361328,0.4976010322570801,0.3309409618377686,0.4163867235183716,0.6029030084609985,0.7033473253250122,0.4589484930038452,-0.07025063037872314,-0.7293217182159424,-1.272996544837952,-1.546960830688477,-1.639805555343628,-1.827375650405884,-2.119801878929138,-2.251284956932068,-2.192836999893188,-2.156626462936401,-2.288403391838074,-2.413620352745056,-2.468341469764709,-2.423256635665894,-2.406952977180481,-2.524347424507141,-2.717719554901123,-2.939246654510498,-3.205378293991089,-3.380243897438049,-3.477662563323975,-3.495790123939514,-3.293831467628479,-2.856334090232849,-2.489697337150574,-2.220744729042053,-1.983213901519775,-1.982279658317566,-2.084803223609924,-2.123692870140076,-2.116918087005615,-2.211394190788269,-2.366626501083374,-2.285754680633545,-1.871771454811096,-1.389598608016968,-1.019832849502563,-0.5889562368392944,0.001264572143554688,0.4352762699127197,0.4553554058074951,0.2969251871109009,0.08830523490905762,-0.321566104888916,-0.7534559965133667,-0.8693913221359253,-0.8736552000045776,-1.148306488990784,-1.371173143386841,-1.124054670333862,-0.8013516664505005,-0.7516665458679199,-0.7146291732788086,-0.6144503355026245,-0.7853702306747437,-1.120617628097534,-1.144364833831787,-0.8276563882827759,-0.5106358528137207,-0.4326214790344238,-0.5659912824630737,-0.7853823900222778,-0.9494302272796631,-1.109988331794739,-1.379182100296021,-1.398316860198975,-0.8649106025695801,-0.3790595531463623,-0.4004964828491211,-0.5715116262435913,-0.492473840713501,-0.1759498119354248,0.2315930128097534,0.4601401090621948,0.3751847743988037,0.169446587562561,0.1308406591415405,0.530530571937561,1.262857675552368,1.767407774925232,1.807302594184875,1.790277481079102,1.880370140075684,1.953804492950439,1.992536067962646,2.136393308639526,2.313253045082092,2.306374907493591,2.262749195098877,2.46766459941864,2.866497278213501,3.18609356880188,3.30308473110199,3.179061412811279,2.835442304611206,2.430811643600464,2.193682074546814,2.152919888496399,2.234954953193665,2.153296828269958,1.925967693328857,1.94564962387085,2.234924554824829,2.339452385902405,2.072548627853394,1.567139267921448,1.17378032207489,1.303163886070251,1.953164100646973,2.494729280471802,2.480729818344116,2.297012209892273,2.375533223152161,2.544797420501709,2.53822124004364,2.562371730804443,2.630492448806763,2.542282462120056,2.524469017982483,2.744836926460266,2.838844895362854,2.582394123077393,2.359235644340515,2.402719497680664,2.650312185287476,2.867334246635437,2.901737093925476,2.806363224983215,2.532607674598694,1.979926824569702,1.314445734024048,0.9242157936096191,0.9905288219451904,1.242253661155701,1.39927339553833,1.308430910110474,0.9935686588287354,0.7389438152313232,0.4923785924911499,0.05946731567382812,-0.2910724878311157,-0.1968091726303101,0.03543639183044434,-0.05724620819091797,-0.3822007179260254,-0.6849846839904785,-0.935171365737915,-1.343782186508179,-1.856783032417297,-2.059694170951843,-1.920163631439209,-1.919829249382019,-2.035310626029968,-1.880376219749451,-1.473236680030823,-1.48635458946228,-2.155177474021912,-2.816769599914551,-2.731528520584106,-2.155017375946045,-1.798732280731201,-1.788688659667969,-1.818483114242554,-1.849663734436035,-1.85445249080658,-1.679463267326355,-1.515318155288696,-1.647411227226257,-1.744919061660767,-1.502370476722717,-1.211500644683838,-1.234412908554077,-1.620028376579285,-2.135615110397339,-2.39510977268219,-2.147036790847778,-1.538301348686218,-0.8162063360214233,-0.07978761196136475,0.3498568534851074,0.1788579225540161,-0.3024455308914185,-0.6083402633666992,-0.5850226879119873,-0.1448887586593628,0.5342614650726318,0.9967381954193115,1.152489304542542,1.15303647518158,1.191553235054016,1.344404339790344,1.557541489601135,1.521715998649597,1.289257645606995,1.150720119476318,1.127384305000305,1.231472373008728,1.562291741371155,1.705162048339844,1.369584321975708,1.011136889457703,1.115956544876099,1.450995206832886,1.705358624458313,1.713284492492676,1.468038558959961,1.133585572242737,1.007782936096191,1.196279168128967,1.392668843269348,1.300176739692688,1.28914213180542,1.775674104690552,2.290148258209229,2.095746636390686,1.377437233924866,0.7166759967803955,0.3834247589111328,0.456905722618103,0.882253885269165,1.27365517616272,1.436266183853149,1.666497349739075,2.14018702507019,2.481684327125549,2.368434190750122,2.179080724716187,2.314130544662476,2.344954490661621,1.945773243904114,1.535786390304565,1.298484563827515,0.8217854499816895,0.2833330631256104,0.2814280986785889,0.857440710067749,1.420929193496704,1.646758675575256,1.417486071586609,0.7776044607162476,0.1439281702041626,-0.02024328708648682,0.2363148927688599,0.5090287923812866,0.5058714151382446,0.4051170349121094,0.3283125162124634,0.1157934665679932,-0.367465615272522,-0.9512683153152466,-1.486200571060181,-1.700377345085144,-1.494231820106506,-0.9978771209716797,-0.3332816362380981,0.200752854347229,0.2025038003921509,-0.2968441247940063,-0.8459967374801636,-1.267530918121338,-1.594982147216797,-1.57655668258667,-1.019119501113892,-0.3740620613098145,-0.1099731922149658,-0.07445573806762695,-0.01621448993682861,-0.01916515827178955,-0.3161896467208862,-0.8038443326950073,-0.971621036529541,-0.6313437223434448,-0.2005218267440796,-2.026557922363281e-05,0.2294833660125732,0.446774959564209,0.1749567985534668,-0.6107984781265259,-1.253902316093445,-1.436274290084839,-1.624496936798096,-2.022350788116455,-2.303886294364929,-2.326443910598755,-2.177046060562134,-1.807892322540283,-1.235559940338135,-0.681249737739563,-0.4223529100418091,-0.3656538724899292,-0.2818334102630615,-0.3064844608306885,-0.7051063776016235,-1.274184107780457,-1.559728145599365,-1.38267183303833,-1.194917321205139,-1.403314352035522,-1.680344820022583,-1.706373929977417,-1.748799920082092,-1.80175793170929,-1.567631721496582,-1.285330176353455,-1.177379488945007,-1.019451856613159,-0.7891274690628052,-0.8716367483139038,-1.158260941505432,-1.274145603179932,-1.209445714950562,-1.286981821060181,-1.430056810379028,-1.418475031852722,-1.239475250244141,-1.038633227348328,-0.8688259124755859,-0.6629033088684082,-0.3843833208084106,-0.1237943172454834,-0.02087152004241943,0.2266603708267212,0.8003160953521729,1.519476652145386,2.052112817764282,2.324313998222351,2.388606548309326,2.379809260368347,2.365941524505615,2.28359842300415,2.192930221557617,2.056137561798096,1.848366737365723,1.724582552909851,1.796995520591736,1.847138643264771,1.873637914657593,2.013107657432556,2.174555420875549,2.133430480957031,2.148068308830261,2.56001079082489,3.20158863067627,3.59753143787384,3.642770290374756,3.338010430335999,2.654565930366516,1.789647221565247,1.129504084587097,1.017808318138123,1.319143295288086,1.587477803230286,1.699809908866882,1.84144401550293,1.941353321075439,1.862747192382812,1.758032917976379,1.818547964096069,1.751801252365112,1.177653074264526,0.1397696733474731,-0.7968871593475342,-1.035094857215881,-0.6906286478042603,-0.164637565612793,0.4368873834609985,1.08039653301239,1.386333823204041,1.277846097946167,1.123191356658936,1.243516206741333,1.357767462730408,1.166488766670227,1.014134168624878,1.373485445976257,1.934744715690613,2.031373023986816,1.694887399673462,1.556376218795776,1.915922045707703,2.468051671981812,3.057449698448181,3.692593216896057,4.114326000213623,3.945067882537842,3.321990489959717,2.846511363983154,2.747655868530273,2.738848447799683,2.518245458602905,2.451202869415283,2.703758597373962,2.855405926704407,2.64313817024231,2.331488013267517,2.161840796470642,2.030515789985657,1.878260493278503,1.830310106277466,1.942354440689087,2.173979878425598,2.213777422904968,1.884591460227966,1.352117419242859,0.6777579784393311,-0.2265245914459229,-1.278905987739563,-1.94074535369873,-1.914653420448303,-1.827361464500427,-2.199190258979797,-2.308855414390564,-1.549828410148621,-0.6508837938308716,-0.4701229333877563,-0.8092937469482422,-1.148186922073364,-1.357106804847717,-1.507155179977417,-1.421340584754944,-1.014444231987,-0.7620891332626343,-1.250055909156799,-2.039304971694946,-2.099941611289978,-1.41343092918396,-0.8197548389434814,-0.6954498291015625,-0.9543243646621704,-1.54583203792572,-1.952173113822937,-1.621086239814758,-0.7349859476089478,0.2001854181289673,0.9077459573745728,1.128962993621826,1.032952785491943,1.04490339756012,1.114874362945557,1.064384698867798,1.353031396865845,2.152530789375305,2.422527074813843,1.532414197921753,0.4232547283172607,-0.1097320318222046,-0.5515196323394775,-0.9690554141998291,-0.6140186786651611,0.2167140245437622,0.5444084405899048,0.6284254789352417,1.054359316825867,1.415568947792053,1.154151082038879,0.4857760667800903,-0.1195709705352783,-0.538261890411377,-0.5234619379043579,-0.03502500057220459,0.4892597198486328,0.4523216485977173,-0.0923076868057251,-0.5290228128433228,-0.5883989334106445,-0.6491328477859497,-1.068058848381042,-1.561655402183533,-1.736125826835632,-1.576137185096741,-1.100309491157532,-0.4042618274688721,-0.009105324745178223,-0.2454546689987183,-0.5695641040802002,-0.4381316900253296,-0.2375855445861816,-0.6558670997619629,-1.25033962726593,-1.222865581512451,-0.7874413728713989,-0.7118102312088013,-0.9716818332672119,-1.035719037055969,-0.8713631629943848,-0.9402337074279785,-1.294163942337036,-1.442990303039551,-1.359419107437134,-1.317807793617249,-1.313325047492981,-1.116562485694885,-0.845597505569458,-0.8227622509002686,-1.053542613983154,-1.130322813987732,-0.8537017107009888,-0.6128756999969482,-0.6820117235183716,-0.6749836206436157,0.07591080665588379,1.320857763290405,2.130682468414307,2.127253532409668,1.842655897140503,1.579288482666016,1.154842138290405,0.6660566329956055,0.5772629976272583,0.89970862865448,1.099288105964661,1.183274745941162,1.662304401397705,2.434489846229553,3.060866475105286,3.541718006134033,4.033839225769043,4.096220731735229,3.399779915809631,2.609835743904114,2.422340631484985,2.183391213417053,1.421081185340881,0.7583785057067871,0.4711909294128418,0.3206825256347656,0.1797962188720703,-0.01084005832672119,-0.4045273065567017,-1.043699622154236,-1.863665223121643,-2.583447933197021,-3.002874493598938,-3.09234094619751,-2.896727442741394,-2.692034959793091,-2.692288279533386,-2.607711911201477,-2.177974224090576,-1.907451033592224,-2.05014705657959,-1.971285581588745,-1.643982291221619,-1.734342455863953,-1.945797562599182,-1.670291066169739,-1.316944479942322,-1.418572306632996,-1.404734969139099,-0.940760612487793,-0.6032900810241699,-0.6037967205047607,-0.4628455638885498,-0.02796852588653564,0.3913364410400391,0.8355822563171387,1.402185559272766,1.906018257141113,2.189963340759277,2.374890804290771,2.45955228805542,2.230182409286499,1.804041862487793,1.765249490737915,2.248202562332153,2.640183448791504,2.513016939163208,2.124657511711121,1.803334593772888,1.526978969573975,1.521332979202271,1.986458420753479,2.562304854393005,2.800690889358521,2.770560026168823,2.637449622154236,2.49765157699585,2.362093091011047,2.320603370666504,2.570103049278259,3.040998101234436,3.229210615158081,2.917730689048767,2.420076966285706,2.086426496505737,1.903114199638367,1.917912125587463,2.12288224697113,2.228737473487854,2.089703440666199,1.879575729370117,1.793224096298218,1.669087290763855,1.470956802368164,1.559081673622131,1.847809433937073,1.836545825004578,1.683188080787659,1.981347441673279,2.347364068031311,2.16887903213501,1.817668437957764,1.670745015144348,1.631835103034973,1.830251336097717,2.133706092834473,2.008973479270935,1.399603724479675,0.7400158643722534,0.2011014223098755,-0.1114890575408936,-0.1538258790969849,-0.1232694387435913,-0.2405422925949097,-0.4068983793258667,-0.3388181924819946,0.02549409866333008,0.3922078609466553,0.4976253509521484,0.1750459671020508,-0.3824094533920288,-0.9073021411895752,-1.320675373077393,-1.684189200401306,-1.764011263847351,-1.66123640537262,-1.756294131278992,-2.025629758834839,-2.061593055725098,-1.675483107566833,-1.216469764709473,-0.9577391147613525,-1.081894159317017,-1.416711926460266,-1.616301536560059,-1.676283597946167,-1.750072598457336,-1.757414817810059,-1.517058968544006,-1.091348052024841,-0.6944872140884399,-0.4616802930831909,-0.4079825878143311,-0.4934567213058472,-0.7513787746429443,-0.9567217826843262,-1.055970430374146,-1.179016947746277,-1.226166844367981,-0.9803088903427124,-0.4123802185058594,0.2089887857437134,0.7234852313995361,0.9241327047348022,0.5897952318191528,-0.1840682029724121,-0.9942374229431152,-1.656435489654541,-2.164992094039917,-2.300451278686523,-1.801117539405823,-0.8699121475219727,-0.1231883764266968,0.0999680757522583,0.02250897884368896,-0.002156257629394531,0.09183549880981445,0.07943093776702881,-0.00168609619140625,-0.1218447685241699,-0.3429827690124512,-0.5375100374221802,-0.4186098575592041,-0.2525496482849121,-0.4353005886077881,-0.8040794134140015,-0.873456597328186,-0.4871865510940552,0.1207950115203857,0.6967670917510986,1.082627773284912,1.103144645690918,0.7010390758514404,0.08104813098907471,-0.3968527317047119,-0.6992901563644409,-0.8400264978408813,-0.6427350044250488,-0.4287345409393311,-0.6560454368591309,-1.005756378173828,-1.0465327501297,-1.073824405670166,-1.330459594726562,-1.437200427055359,-1.197110056877136,-1.052146315574646,-1.073419094085693,-0.9611964225769043,-0.7297087907791138,-0.6519132852554321,-0.7333505153656006,-0.8840858936309814,-1.101624727249146,-1.253894209861755,-1.006714940071106,-0.3016815185546875,0.3122135400772095,0.3172900676727295,-0.02803134918212891,-0.1224446296691895,0.3476377725601196,1.132624983787537,1.829781174659729,2.275253057479858,2.649777173995972,2.923342227935791,2.971626996994019,2.886724352836609,2.817531585693359,2.665353298187256,2.328182697296143,2.129132151603699,2.23368227481842,2.566532254219055,2.891762375831604,3.108610153198242,3.164014220237732,3.096582531929016,2.862699508666992,2.496861219406128,1.964551329612732,1.284999847412109,0.6130216121673584,0.04489636421203613,-0.4073138236999512,-0.7290096282958984,-0.9900606870651245,-1.15973424911499,-1.217918753623962,-1.226004719734192,-1.225755453109741,-1.179908633232117,-1.164701342582703,-1.129514217376709,-1.121770739555359,-1.209672689437866,-1.455007791519165,-1.780288577079773,-2.151053428649902,-2.231894850730896,-1.970146656036377,-1.747158408164978,-1.642707586288452,-1.357542514801025,-0.8767517805099487,-0.4191772937774658,-0.01409065723419189,0.3191403150558472,0.4677619934082031,0.3631997108459473,0.3428125381469727,0.6661883592605591,0.8951346874237061,0.747433066368103,0.5153942108154297,0.452414870262146,0.4186017513275146,0.4521149396896362,0.6297042369842529,0.9363244771957397,1.169194221496582,1.323415279388428,1.66304612159729,2.21326470375061,2.477465033531189,2.359519362449646,2.327809810638428,2.549890160560608,2.85254442691803,3.181906700134277,3.46709406375885,3.444508075714111,2.988765597343445,2.249842047691345,1.577549695968628,1.070284008979797,0.7089325189590454,0.5723810195922852,0.8100597858428955,1.176386475563049,1.473846673965454,1.612122774124146,1.360235810279846,1.006988525390625,1.028364658355713,1.360057473182678,1.303850889205933,0.8390740156173706,0.3244336843490601,-0.1646071672439575,-0.7129248380661011,-1.181698083877563,-1.437220692634583,-1.45715594291687,-1.291499018669128,-0.9229329824447632,-0.3875933885574341,0.01370155811309814,0.03230941295623779,-0.37757408618927,-1.09451961517334,-1.635458588600159,-1.722081780433655,-1.698529124259949,-1.884293556213379,-2.042377233505249,-1.950797080993652,-1.589844822883606,-1.351592540740967,-1.486214756965637,-1.799050450325012,-1.776063203811646,-1.296437740325928,-0.7256759405136108,-0.4375946521759033,-0.4441059827804565,-0.7579346895217896,-1.317209959030151,-1.877342462539673,-2.290196895599365,-2.426320791244507,-2.228251099586487,-1.855109095573425,-1.362203598022461,-0.9179273843765259,-0.7694516181945801,-0.9568231105804443,-1.10526442527771,-0.7842150926589966,-0.003793716430664062,0.682064414024353,0.6650879383087158,-0.01894426345825195,-0.7300593852996826,-0.9052512645721436,-0.6576687097549438,-0.4928284883499146,-0.7209115028381348,-1.015579104423523,-1.053021788597107,-0.8523499965667725,-0.4161050319671631,-0.002557516098022461,-0.08286392688751221,-0.7163983583450317,-1.271908283233643,-1.193223118782043,-0.6867944002151489,-0.3831795454025269,-0.6571296453475952,-1.189628005027771,-1.52441942691803,-1.718851447105408,-1.921797037124634,-2.191983819007874,-2.419521689414978,-2.525522828102112,-2.492346048355103,-2.338824152946472,-2.19607949256897,-2.137258648872375,-2.07931125164032,-1.906705260276794,-1.688643574714661,-1.654352188110352,-1.829981803894043,-2.045461654663086,-2.293646097183228,-2.597615599632263,-2.710780620574951,-2.409852981567383,-2.040841102600098,-1.844311594963074,-1.602150082588196,-1.147939682006836,-0.597388744354248,-0.1426291465759277,0.09462809562683105,0.09424507617950439,0.1503300666809082,0.3907912969589233,0.6272784471511841,0.7653518915176392,0.7836800813674927,0.8200912475585938,1.088478446006775,1.41650116443634,1.300426006317139,0.6016303300857544,-0.1837459802627563,-0.3937257528305054,0.2079126834869385,1.133058667182922,1.606559872627258,1.631381154060364,1.73957097530365,1.775062084197998,1.280381321907043,0.4282907247543335,-0.2670415639877319,-0.6257585287094116,-0.5361968278884888,-0.04129517078399658,0.7114758491516113,1.424046039581299,1.674854874610901,1.55287230014801,1.414594173431396,1.356985211372375,1.20701789855957,1.048956513404846,1.199912786483765,1.805894136428833,2.431249380111694,2.443560719490051,1.813475489616394,1.139754414558411,0.6864356994628906,0.3227131366729736,0.07229137420654297,0.1599602699279785,0.5675821304321289,0.9098860025405884,0.9719088077545166,1.094772934913635,1.391594767570496,1.440866470336914,0.9759234189987183,0.2773547172546387,-0.2289422750473022,-0.3001494407653809,-0.002829074859619141,0.2170463800430298,-0.026458740234375,-0.6574660539627075,-1.296569466590881,-1.660778403282166,-1.786449313163757,-1.752624034881592,-1.548342943191528,-1.060491681098938,-0.4361943006515503,-0.02176320552825928,-0.08636581897735596,-0.4789323806762695,-0.809778094291687,-0.8818364143371582,-0.6857486963272095,-0.5199235677719116,-0.5792044401168823,-0.5473124980926514,-0.2632154226303101,-0.03019165992736816,0.2104175090789795,0.5391961336135864,0.8127814531326294,1.153154015541077,1.761569261550903,2.397987484931946,2.723791122436523,2.608921766281128,2.228911757469177,1.96039891242981,1.922629952430725,1.834655046463013,1.468553304672241,1.223262786865234,1.380446672439575,1.759621739387512,2.04173481464386,2.128615379333496,2.163636326789856,2.155309200286865,2.111732125282288,2.197100877761841,2.32055675983429,2.189091920852661,1.863097786903381,1.627745509147644,1.443922519683838,1.165961861610413,1.095589637756348,1.318036794662476,1.290058135986328,0.8093342781066895,0.365033745765686,0.3529919385910034,0.5131649971008301,0.3400037288665771,-0.2052538394927979,-0.7320636510848999,-1.091358184814453,-1.431722640991211,-1.757506012916565,-1.935879588127136,-2.11329460144043,-2.491251707077026,-2.946163296699524,-3.292171716690063,-3.41840398311615,-3.010859131813049,-2.074804186820984,-1.317309260368347,-1.375295162200928,-1.826838612556458,-1.971956372261047,-1.627196311950684,-1.241116762161255,-1.168176889419556,-1.448129653930664,-1.910640835762024,-2.384944558143616,-2.8067786693573,-3.152002811431885,-3.287022233009338,-3.258060693740845,-3.107521891593933,-2.628291606903076,-2.102847695350647,-1.85593593120575,-1.780055522918701,-1.938327670097351,-2.406588196754456,-2.726123690605164,-2.679575681686401,-2.558026790618896,-2.5256667137146,-2.369283318519592,-2.014538407325745,-1.805383443832397,-1.804878830909729,-1.498975992202759,-0.9784890413284302,-0.9334731101989746,-1.190053582191467,-1.007203340530396,-0.5713170766830444,-0.6701968908309937,-1.230706334114075,-1.570955276489258,-1.346777439117432,-0.7079516649246216,0.01934349536895752,0.7028812170028687,1.101993560791016,0.8956737518310547,0.1543527841567993,-0.4666413068771362,-0.4442296028137207,0.36616051197052,1.224563837051392,1.490561723709106,1.527905106544495,1.784807801246643,1.835725069046021,1.323095083236694,0.7343070507049561,0.5326807498931885,0.4723258018493652,-0.007970452308654785,-0.874516487121582,-1.4644535779953,-1.380805373191833,-0.9069677591323853,-0.511239767074585,-0.4838467836380005,-0.8843250274658203,-1.593496680259705,-2.199832677841187,-2.413210988044739,-2.229600787162781,-1.806848645210266,-1.543562293052673,-1.672313570976257,-1.922380685806274,-2.002176403999329,-1.900222301483154,-1.691825270652771,-1.42595911026001,-1.228154897689819,-1.387290358543396,-1.975083351135254,-2.595933556556702,-2.898062944412231,-2.825883030891418,-2.264139413833618,-1.248114466667175,-0.1470612287521362,0.5567096471786499,0.7178291082382202,0.675520658493042,0.6321320533752441,0.4713712930679321,0.1337852478027344,-0.07567369937896729,0.1385111808776855,0.7663530111312866,1.415526390075684,1.580735445022583,1.24299943447113,0.8707612752914429,0.7295000553131104,0.8499991893768311,1.153875470161438,1.373163223266602,1.095723390579224,0.1986796855926514,-0.8930858373641968,-1.311651110649109,-0.926033616065979,-0.5551877021789551,-0.8204600811004639,-1.478248357772827,-2.076311945915222,-2.372969627380371,-2.482272028923035,-2.386975169181824,-2.16412878036499,-2.109288096427917,-2.321499109268188,-2.536559462547302,-2.404664993286133,-2.015768527984619,-1.743447780609131,-1.647271394729614,-1.730504155158997,-2.00052273273468,-2.156423807144165,-2.121581196784973,-1.895003914833069,-1.379212498664856,-0.4721353054046631,0.6204671859741211,1.365411639213562,1.254252910614014,0.3365383148193359,-0.6902618408203125,-1.077790379524231,-0.6964185237884521,0.05731916427612305,0.6908454895019531,1.079231262207031,1.365363001823425,1.611328363418579,1.728694438934326,1.659783363342285,1.488113641738892,1.364637494087219,1.083566069602966,0.8497661352157593,1.020860314369202,1.34717869758606,1.420027375221252,1.403026580810547,1.457431554794312,1.114858150482178,0.1558281183242798,-0.7536343336105347,-0.993432879447937,-0.7021090984344482,-0.2256977558135986,0.1685305833816528,0.3103065490722656,0.2778714895248413,0.371733546257019,0.7519381046295166,0.9572324752807617,0.6261334419250488,0.1026350259780884,-0.3451815843582153,-0.6871753931045532,-0.7051104307174683,-0.2454668283462524,0.3945181369781494,0.7183296680450439,0.9764827489852905,1.751481056213379,2.666216611862183,2.554699182510376,1.239341497421265,-0.02307641506195068,-0.4388267993927002,-0.3076193332672119,-0.1422441005706787,0.02521038055419922,0.3254631757736206,0.8452996015548706,1.6659015417099,2.42808997631073,2.774906992912292,2.935923099517822,3.082121014595032,2.956928372383118,2.659010171890259,2.680412650108337,2.907804608345032,2.686320066452026,1.914246082305908,1.180619955062866,0.7634550333023071,0.5221264362335205,0.4135292768478394,0.6295826435089111,0.9217028617858887,1.052960991859436,1.256097078323364,1.579397916793823,1.728439092636108,1.539778709411621,1.124776124954224,0.9296996593475342,1.057449817657471,0.8965086936950684,0.1245542764663696,-0.6603802442550659,-0.8585755825042725,-0.5570156574249268,-0.1061450242996216,0.1363123655319214,0.09706807136535645,0.009826779365539551,-0.04005289077758789,-0.1480177640914917,-0.1858596801757812,-0.2055517435073853,-0.4783710241317749,-0.8832104206085205,-1.08392071723938,-1.215193033218384,-1.429134726524353,-1.587534546852112,-1.485335230827332,-1.141815423965454,-0.7535431385040283,-0.7177338600158691,-1.153707265853882,-1.513307809829712,-1.34101390838623,-0.8967843055725098,-0.8257656097412109,-1.094572305679321,-1.145213961601257,-0.9530091285705566,-0.8945935964584351,-1.072413921356201,-1.292226552963257,-1.46086049079895,-1.4302898645401,-1.038726449012756,-0.3760784864425659,0.07821905612945557,-0.007311820983886719,-0.3884283304214478,-0.6091346740722656,-0.5821672677993774,-0.5369608402252197,-0.6081801652908325,-0.9803757667541504,-1.706276655197144,-2.384521007537842,-2.774959683418274,-3.155770182609558,-3.753197431564331,-4.361227631568909,-4.680236220359802,-4.572376728057861,-4.12207555770874,-3.450356721878052,-2.955067992210388,-3.082370281219482,-3.732291460037231,-4.33693528175354,-4.705501317977905,-5.023425698280334,-5.362363457679749,-5.485657215118408,-5.437348127365112,-5.343429327011108,-5.234992265701294,-5.276684641838074,-5.583345413208008,-5.934272289276123,-5.993263363838196,-5.62178111076355,-5.08874773979187,-4.795788526535034,-4.790632963180542,-4.664352059364319,-4.080366969108582,-3.110727906227112,-2.237315893173218,-1.960956215858459,-2.126485466957092,-2.25388503074646,-2.166998386383057,-1.961365580558777,-1.710858702659607,-1.407736301422119,-0.9238530397415161,-0.3216654062271118,0.09726059436798096,0.1477745771408081,-0.03311598300933838,-0.119641900062561,0.09810769557952881,0.5309399366378784,0.9949750900268555,1.310171723365784,1.484563112258911,1.511449456214905,1.34731650352478,1.153178334236145,0.823199987411499,0.176636815071106,-0.2175955772399902,0.1582802534103394,1.067683935165405,1.930979371070862,2.477193474769592,2.455377578735352,1.780712127685547,0.8554972410202026,0.3113948106765747,0.1376113891601562,-0.06459653377532959,-0.3502682447433472,-0.4564902782440186,-0.4388328790664673,-0.4803712368011475,-0.6673110723495483,-0.7560479640960693,-0.5212752819061279,-0.08733248710632324,0.5027565956115723,1.135514855384827,1.445979475975037,1.373171329498291,1.164715528488159,0.9780675172805786,0.9376802444458008,1.271247625350952,2.059633374214172,2.884503245353699,3.266979575157166,3.364426612854004,3.271229267120361,2.877274513244629,2.577112913131714,3.081342816352844,4.095545887947083,4.651503682136536,4.788971185684204,4.724046349525452,4.276645183563232,3.926162123680115,4.140407800674438,4.516431570053101,4.531081557273865,4.255706787109375,4.016962051391602,3.986251592636108,3.987858653068542,3.946162223815918,4.006132125854492,4.090740919113159,3.960214376449585,3.787075400352478,4.052629470825195,4.706761837005615,5.094112038612366,4.940910339355469,4.622074007987976,4.314181089401245,3.871866583824158,3.498963713645935,3.439143776893616,3.448044419288635,3.244000434875488,2.824999451637268,2.340516328811646,1.958913445472717,1.552566289901733,1.025896310806274,0.422391414642334,-0.2610105276107788,-0.7432117462158203,-0.966544508934021,-1.294032216072083,-1.937500834465027,-2.603705406188965,-2.827040195465088,-2.709943652153015,-2.862010478973389,-3.199671506881714,-3.187246680259705,-3.034452319145203,-3.183171272277832,-3.392814636230469,-3.276003837585449,-3.137381196022034,-3.356504797935486,-3.864994525909424,-4.173760890960693,-4.025366187095642,-3.664247751235962,-3.567412734031677,-3.776225209236145,-3.802223920822144,-3.464840531349182,-3.049961566925049,-2.734075903892517,-2.343742609024048,-1.935944437980652,-1.851657867431641,-2.125318169593811,-2.218329071998596,-1.722967386245728,-1.056185245513916,-0.7927002906799316,-0.6792981624603271,-0.4708808660507202,-0.4386140108108521,-0.5365251302719116,-0.3709350824356079,-0.12336266040802,-0.3008384704589844,-0.6737595796585083,-0.9129461050033569,-1.229036450386047,-1.488814830780029,-1.153849124908447,-0.5771191120147705,-0.3217140436172485,-0.2761590480804443,-0.2099838256835938,-0.4123518466949463,-1.033139228820801,-1.816855788230896,-2.329416871070862,-2.76156210899353,-3.521310567855835,-4.350170731544495,-4.559360146522522,-4.099651694297791,-3.300235390663147,-2.721942901611328,-2.80195951461792,-3.324517607688904,-3.73734974861145,-3.943057537078857,-4.248111248016357,-4.814973950386047,-5.152233719825745,-4.834872722625732,-4.146007180213928,-3.411298871040344,-2.615088582038879,-1.89939546585083,-1.515109419822693,-1.306797504425049,-1.073469758033752,-0.9876977205276489,-1.205108880996704,-1.459143996238708,-1.290483713150024,-0.6103972196578979,0.2790874242782593,1.144387125968933,1.593310236930847,1.230015277862549,0.4951934814453125,0.1617274284362793,0.1609532833099365,0.07580339908599854,0.1128610372543335,0.3830944299697876,0.7025407552719116,0.9554105997085571,1.210039496421814,1.192078113555908,0.5696674585342407,-0.2231990098953247,-0.4818587303161621,-0.1727437973022461,0.3957908153533936,0.8309779167175293,0.9151611328125,0.8875553607940674,0.9919291734695435,1.188827514648438,1.278101444244385,0.9112640619277954,0.005990505218505859,-0.8775928020477295,-1.395735025405884,-1.610319137573242,-1.730094790458679,-1.818061590194702,-1.601373910903931,-1.130805134773254,-0.8708930015563965,-0.9620921611785889,-0.93198561668396,-0.7126107215881348,-0.5743792057037354,-0.3912574052810669,0.1113269329071045,0.8790782690048218,1.465886354446411,1.748159527778625,1.859818816184998,1.848873376846313,1.737501859664917,1.966464400291443,2.581050515174866,3.0744788646698,3.185289025306702,2.99779999256134,2.787654042243958,2.838113307952881,2.950238704681396,2.762816548347473,2.722648143768311,3.181199431419373,3.460904955863953,3.055873036384583,2.559617638587952,2.301969170570374,1.916122674942017,1.341688752174377,0.8375844955444336,0.8463817834854126,1.536315321922302,2.303091883659363,2.444900274276733,1.927915215492249,1.237043380737305,0.6599647998809814,0.1864169836044312,-0.04483354091644287,0.2389818429946899,1.033408761024475,2.189691781997681,3.422730684280396,4.51554799079895,5.01922869682312,4.637852787971497,3.668959498405457,2.857582449913025,2.456113219261169,1.980563163757324,1.47790789604187,1.33183765411377,1.647275447845459,2.214308381080627,2.764243245124817,3.069913029670715,2.903565049171448,2.128161430358887,0.9046554565429688,-0.28971266746521,-1.085199475288391,-1.40312385559082,-1.508134007453918,-1.626511335372925,-1.721427202224731,-1.665026068687439,-1.602486491203308,-1.601588726043701,-1.706023335456848,-2.087184429168701,-2.731384634971619,-3.365502715110779,-3.619306802749634,-3.542076706886292,-3.599505305290222,-3.966654777526855,-4.199017882347107,-3.891335725784302,-3.185307264328003,-2.380024075508118,-1.873400807380676,-1.832594037055969,-2.166439056396484,-2.722303628921509,-3.370810270309448,-3.876270294189453,-3.885953187942505,-3.325668692588806,-2.446914672851562,-1.562640309333801,-1.076197504997253,-1.39397394657135,-2.290735960006714,-3.108296036720276,-3.422973871231079,-3.450425624847412,-3.423119783401489,-3.29071056842804,-3.139162540435791,-3.435281157493591,-3.992311000823975,-4.045862793922424,-3.434701561927795,-2.744387030601501,-2.418423295021057,-2.397126197814941,-2.635127186775208,-3.06047534942627,-3.469375967979431,-3.700960874557495,-3.753554105758667,-3.608693718910217,-3.335191488265991,-3.037388801574707,-2.699549436569214,-2.34244966506958,-2.360510349273682,-2.988666296005249,-3.747551441192627,-3.963558197021484,-3.585817933082581,-2.76667308807373,-1.471416831016541,-0.07028305530548096,0.6770243644714355,0.6757881641387939,0.4898210763931274,0.2095582485198975,-0.2550909519195557,-0.7344813346862793,-0.7467906475067139,-0.03433191776275635,1.071893095970154,1.961987733840942,2.333859086036682,2.080221176147461,1.371541976928711,0.698548436164856,0.7562566995620728,1.290013551712036,1.352050542831421,1.086004018783569,1.377117037773132,2.004069209098816,1.999787092208862,1.496355652809143,1.355311274528503,1.856363534927368,2.598493099212646,3.462345838546753,4.298019289970398,4.545737624168396,4.016708731651306,3.171451687812805,2.501688480377197,2.061716675758362,1.611004114151001,1.324256300926208,1.305336356163025,1.269486546516418,1.262251734733582,1.546847343444824,1.756127953529358,1.723263263702393,2.047508478164673,3.02411687374115,3.863022685050964,4.157846331596375,4.689215898513794,5.703840494155884,6.102306365966797,5.445227384567261,4.608627796173096,4.04859459400177,3.145761013031006,1.938728928565979,1.468660712242126,1.885501384735107,2.260161280632019,2.339847564697266,2.691852569580078,3.220101237297058,3.402007102966309,3.356527090072632,3.217205286026001,2.772312998771667,2.094074726104736,1.847414255142212,2.211248278617859,2.369946002960205,1.608525633811951,0.2929551601409912,-0.8099827766418457,-1.263652086257935,-1.06257700920105,-0.4778522253036499,0.08486819267272949,0.3460286855697632,0.5099812746047974,0.6741446256637573,0.7228448390960693,0.6007447242736816,0.1999138593673706,-0.5003936290740967,-1.040367960929871,-1.171518683433533,-1.300636768341064,-1.747075319290161,-2.134293794631958,-2.183575630187988,-2.318135023117065,-2.786531329154968,-3.076274394989014,-2.8112553358078,-2.499424815177917,-2.695769906044006,-3.119792699813843,-3.052583932876587,-2.451113700866699,-1.866097092628479,-1.54587459564209,-1.426510334014893,-1.433856606483459,-1.391163110733032,-1.324708223342896,-1.538753271102905,-2.27452552318573,-3.108194708824158,-3.588154554367065,-3.940279126167297,-4.158930540084839,-3.81735622882843,-2.912771701812744,-2.067046523094177,-1.860627412796021,-2.174028515815735,-2.715243101119995,-3.488285779953003,-4.364917993545532,-4.719533205032349,-4.47978937625885,-4.136879563331604,-4.068586587905884,-4.207600355148315,-4.212251305580139,-3.777135133743286,-2.757460355758667,-1.472537517547607,-0.4410641193389893,0.09946143627166748,0.1714913845062256,-0.2119961977005005,-0.8752440214157104,-1.534351587295532,-2.110903263092041,-2.411389112472534,-2.100687384605408,-0.8488075733184814,1.072000503540039,2.644031882286072,3.23374605178833,3.270453095436096,3.054217338562012,2.486158967018127,1.757988333702087,1.026871085166931,0.6582158803939819,1.285451769828796,2.828754663467407,3.946255445480347,3.940021753311157,3.528798699378967,3.239750742912292,2.74908459186554,1.856489181518555,1.190]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"fft filter output"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"threshold"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"direct audio"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
