<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>hw:2,0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ben/Desktop/field_test/audio_recordings/ar15_youtube</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>50</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>50</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[-0.1910477876663208,-0.19927978515625,-0.09262943267822266,0.04265391826629639,0.09683477878570557,0.02536535263061523,-0.05001318454742432,-0.0005611181259155273,0.1357983350753784,0.2046980857849121,0.07834327220916748,-0.1917164325714111,-0.3861181735992432,-0.3453428745269775,-0.08109593391418457,0.2031636238098145,0.1658415794372559,-0.2317913770675659,-0.5046123266220093,-0.2811393737792969,0.198572039604187,0.4686968326568604,0.3419846296310425,-0.02740514278411865,-0.3286609649658203,-0.3122395277023315,0.01158034801483154,0.3409460783004761,0.3918195962905884,0.2118270397186279,0.03676784038543701,0.01346957683563232,0.1029839515686035,0.09441292285919189,-0.1042444705963135,-0.2782756090164185,-0.2716270685195923,-0.1906677484512329,-0.1387020349502563,-0.1058679819107056,-0.008402705192565918,0.2169610261917114,0.4202072620391846,0.4261438846588135,0.3754693269729614,0.4641076326370239,0.5573978424072266,0.4255609512329102,0.153099536895752,0.003541827201843262,0.01869070529937744,0.05762338638305664,0.02289319038391113,-0.1647820472717285,-0.4356976747512817,-0.4789116382598877,-0.199158787727356,0.09758806228637695,0.1504955291748047,-0.04406964778900146,-0.3029030561447144,-0.353715181350708,-0.191304087638855,-0.1571820974349976,-0.3795093297958374,-0.5338220596313477,-0.3946342468261719,-0.2285305261611938,-0.3526104688644409,-0.6068733930587769,-0.6208662986755371,-0.3442660570144653,-0.01840531826019287,0.1280281543731689,0.04899215698242188,-0.08613801002502441,-0.08075392246246338,0.0795670747756958,0.2784128189086914,0.3792779445648193,0.2866834402084351,0.06761610507965088,-0.03318238258361816,0.1534496545791626,0.4412567615509033,0.4371399879455566,0.0917356014251709,-0.1537162065505981,0.04197394847869873,0.4346566200256348,0.4792900085449219,0.02635884284973145,-0.4096506834030151,-0.293073296546936,0.189689040184021,0.4743571281433105,0.4193472862243652,0.2760546207427979,0.2021033763885498,0.1631852388381958,0.1073051691055298,0.08651769161224365,0.161612868309021,0.2059282064437866,0.05050575733184814,-0.202562689781189,-0.3084040880203247,-0.2423403263092041,-0.1815005540847778,-0.1940218210220337,-0.1673471927642822,-0.04871785640716553,0.07138371467590332,0.131598949432373,0.1244666576385498,0.01751613616943359,-0.1427054405212402,-0.1688276529312134,0.04893755912780762,0.3174872398376465,0.3228411674499512,0.0693819522857666,-0.1371861696243286,-0.1570427417755127,-0.09668838977813721,-0.02645719051361084,0.02634227275848389,0.003064632415771484,-0.05976355075836182,-0.04487490653991699,0.04582369327545166,0.07986080646514893,0.006071686744689941,-0.06642413139343262,-0.05581355094909668,-0.007930517196655273,0.05077028274536133,0.1490305662155151,0.2133651971817017,0.09886682033538818,-0.1691831350326538,-0.3635122776031494,-0.3371683359146118,-0.2041723728179932,-0.1585102081298828,-0.1976776123046875,-0.1296396255493164,0.1002433300018311,0.2396453619003296,0.09282016754150391,-0.125989556312561,-0.07850062847137451,0.1974078416824341,0.296148419380188,-0.01627957820892334,-0.419898509979248,-0.4598989486694336,-0.1936328411102295,0.01222050189971924,0.05327987670898438,0.02410805225372314,-0.08145856857299805,-0.2444988489151001,-0.2543576955795288,0.03167819976806641,0.3800982236862183,0.4191371202468872,0.1277997493743896,-0.1675810813903809,-0.1854244470596313,0.04726874828338623,0.2223259210586548,0.1349772214889526,-0.01442360877990723,0.02330303192138672,0.1356911659240723,0.0977473258972168,-0.07470989227294922,-0.186718225479126,-0.1154040098190308,0.04070866107940674,0.1259009838104248,0.1529233455657959,0.1487275362014771,0.0542224645614624,-0.04763436317443848,-0.003754734992980957,0.1231006383895874,0.1599199771881104,0.06701743602752686,-0.02451562881469727,0.04493165016174316,0.2303539514541626,0.3004933595657349,0.1155769824981689,-0.2107152938842773,-0.3394724130630493,-0.118982195854187,0.07175898551940918,-0.03547167778015137,-0.1441401243209839,-0.1623111963272095,-0.3584866523742676,-0.6144777536392212,-0.5995414257049561,-0.2892805337905884,0.08782565593719482,0.1292169094085693,-0.2324488162994385,-0.3579962253570557,0.0934683084487915,0.558483362197876,0.4871916770935059,-0.004441976547241211,-0.3098447322845459,-0.01250147819519043,0.343877911567688,0.04874324798583984,-0.4543846845626831,-0.4305770397186279,-0.06324398517608643,0.2214171886444092,0.3610780239105225,0.3653295040130615,0.2853648662567139,0.1889241933822632,0.1001812219619751,0.1735130548477173,0.4324492216110229,0.5493046045303345,0.3912341594696045,0.2309587001800537,0.2275468111038208,0.2471998929977417,0.142113208770752,-0.05593001842498779,-0.1605619192123413,-0.08091270923614502,0.02621996402740479,0.002091407775878906,-0.07695162296295166,-0.04451847076416016,0.110984206199646,0.2379845380783081,0.1961350440979004,0.008899807929992676,-0.1270270347595215,-0.05540156364440918,0.1050078868865967,0.1237295866012573,-0.02862644195556641,-0.2194154262542725,-0.2859374284744263,-0.1442748308181763,-0.004358530044555664,-0.1161333322525024,-0.2860299348831177,-0.239856481552124,-0.10387122631073,-0.0311654806137085,0.02000844478607178,0.04308974742889404,0.06682443618774414,0.1818379163742065,0.2948551177978516,0.2456029653549194,0.05587780475616455,-0.1135795116424561,-0.1376059055328369,-0.08672976493835449,-0.08712899684906006,-0.08050191402435303,-0.02341020107269287,0.02688992023468018,0.09511709213256836,0.04505288600921631,-0.329399585723877,-0.6775038242340088,-0.5315778255462646,-0.1341022253036499,0.06094706058502197,0.01346981525421143,-0.1256070137023926,-0.2001469135284424,-0.170473575592041,-0.1649987697601318,-0.1391044855117798,0.03811585903167725,0.2078455686569214,0.243804931640625,0.2601697444915771,0.2623962163925171,0.2281653881072998,0.27857506275177,0.3888380527496338,0.3914872407913208,0.2706102132797241,0.1452177762985229,0.1322883367538452,0.2499139308929443,0.3456615209579468,0.2371102571487427,-0.0683448314666748,-0.3264695405960083,-0.2841912508010864,-0.03530585765838623,0.07437396049499512,-0.03423178195953369,-0.1235306262969971,-0.08899366855621338,-0.02411997318267822,0.06017231941223145,0.1526585817337036,0.05614948272705078,-0.2981666326522827,-0.6047370433807373,-0.5961242914199829,-0.3821092844009399,-0.2323442697525024,-0.2922128438949585,-0.4149338006973267,-0.2974231243133545,0.02375781536102295,0.2043002843856812,0.1407575607299805,-0.04792666435241699,-0.2798175811767578,-0.412610650062561,-0.3545655012130737,-0.2228759527206421,-0.1226005554199219,-0.09095990657806396,-0.1546266078948975,-0.1984316110610962,-0.1124505996704102,0.01835799217224121,0.1216285228729248,0.1903989315032959,0.1539556980133057,0.007765769958496094,-0.1248983144760132,-0.1212356090545654,0.08007156848907471,0.3706529140472412,0.5028131008148193,0.4180244207382202,0.3015888929367065,0.3028591871261597,0.4222337007522583,0.5324907302856445,0.4848920106887817,0.3518126010894775,0.3480192422866821,0.4717538356781006,0.5527867078781128,0.5248546600341797,0.3818286657333374,0.1143747568130493,-0.1833409070968628,-0.3485977649688721,-0.2977784872055054,-0.1150869131088257,-0.02264988422393799,-0.1407819986343384,-0.3336726427078247,-0.3906978368759155,-0.2200831174850464,0.07967531681060791,0.2262346744537354,0.04713988304138184,-0.2745182514190674,-0.4449906349182129,-0.3622403144836426,-0.1476212739944458,-0.0520625114440918,-0.1963634490966797,-0.3979839086532593,-0.4369989633560181,-0.3241575956344604,-0.1888072490692139,-0.1234066486358643,-0.1519519090652466,-0.2059149742126465,-0.1909048557281494,-0.1237424612045288,-0.09179592132568359,-0.118833065032959,-0.1809346675872803,-0.2291631698608398,-0.1726099252700806,-0.01666450500488281,0.1168822050094604,0.2017738819122314,0.2668224573135376,0.2532620429992676,0.1614214181900024,0.1002403497695923,0.1235073804855347,0.1982777118682861,0.2397830486297607,0.2054171562194824,0.1755024194717407,0.1902806758880615,0.2271225452423096,0.3573949337005615,0.5317410230636597,0.4970303773880005,0.2710829973220825,0.1780929565429688,0.2884740829467773,0.3392001390457153,0.1823004484176636,-0.04247462749481201,-0.1330187320709229,-0.040901780128479,0.09467875957489014,0.06332182884216309,-0.1550403833389282,-0.2972543239593506,-0.2056834697723389,-0.09232151508331299,-0.1791532039642334,-0.3931688070297241,-0.5176130533218384,-0.3815006017684937,-0.03217232227325439,0.1981334686279297,0.06130194664001465,-0.2626339197158813,-0.4114619493484497,-0.2680239677429199,-0.0297541618347168,0.06035423278808594,0.007403731346130371,-0.006366372108459473,0.06564390659332275,0.1353812217712402,0.1703165769577026,0.1430913209915161,0.03049230575561523,-0.04227912425994873,0.02195000648498535,0.0699918270111084,-0.05155825614929199,-0.2468448877334595,-0.3138853311538696,-0.1581064462661743,0.07912290096282959,0.1186484098434448,-0.06572520732879639,-0.188604474067688,-0.1105189323425293,0.01792323589324951,0.07820117473602295,0.10019850730896,0.1160670518875122,0.1016443967819214,0.03675329685211182,-0.03829681873321533,-0.04427409172058105,0.06279087066650391,0.2239181995391846,0.2834080457687378,0.1729075908660889,0.03300905227661133,0.01340723037719727,0.1228557825088501,0.2763540744781494,0.29662024974823,0.09632492065429688,-0.1107107400894165,-0.1084753274917603,0.02077269554138184,0.06891441345214844,-0.07614016532897949,-0.2824956178665161,-0.2685792446136475,-0.04098653793334961,0.1073168516159058,0.03005087375640869,-0.1799190044403076,-0.2686426639556885,-0.05432224273681641,0.2080912590026855,0.1625804901123047,-0.1033426523208618,-0.3093922138214111,-0.3117467164993286,-0.1244685649871826,0.01944422721862793,-0.05878186225891113,-0.1941026449203491,-0.1649866104125977,0.04796719551086426,0.287353515625,0.3043811321258545,0.08416831493377686,-0.04057037830352783,0.1159584522247314,0.2978591918945312,0.2109788656234741,-0.0492408275604248,-0.1700232028961182,-0.04667496681213379,0.1605892181396484,0.2434365749359131,0.1583312749862671,0.09284877777099609,0.1425564289093018,0.1094509363174438,-0.06518304347991943,-0.1207160949707031,0.05764508247375488,0.2678245306015015,0.2844964265823364,0.06214654445648193,-0.2523237466812134,-0.4040478467941284,-0.2347316741943359,0.07312905788421631,0.1378031969070435,-0.07809555530548096,-0.245234489440918,-0.2035549879074097,-0.04808783531188965,0.08906567096710205,0.09538376331329346,0.007883548736572266,-0.04749572277069092,-0.1063345670700073,-0.2399840354919434,-0.3717237710952759,-0.3770842552185059,-0.2165184020996094,-0.04261672496795654,-0.06824791431427002,-0.2195651531219482,-0.2081186771392822,0.08275282382965088,0.4408109188079834,0.4778116941452026,0.1027704477310181,-0.2260838747024536,-0.08217799663543701,0.3336191177368164,0.5079036951065063,0.2697947025299072,-0.1058712005615234,-0.2926825284957886,-0.1957755088806152,0.06515789031982422,0.2419295310974121,0.1600908041000366,-0.03069424629211426,-0.04637479782104492,0.1199253797531128,0.2214118242263794,0.09817218780517578,-0.1078534126281738,-0.08716857433319092,0.1670991182327271,0.2638885974884033,0.04869997501373291,-0.1474783420562744,-0.1111229658126831,-0.0307697057723999,-0.1102198362350464,-0.2708806991577148,-0.2237588167190552,0.1039421558380127,0.3174746036529541,0.1460511684417725,-0.1102995872497559,-0.1388083696365356,0.007602810859680176,0.1545069217681885,0.1205337047576904,-0.1185014247894287,-0.2933485507965088,-0.2212610244750977,-0.01922225952148438,0.1640692949295044,0.2337453365325928,0.135948657989502,-0.002147555351257324,0.03548157215118408,0.249674916267395,0.3986046314239502,0.299146294593811,0.04311192035675049,-0.1157518625259399,-0.06979906558990479,-0.004035234451293945,-0.08097124099731445,-0.1367934942245483,-0.01888835430145264,0.130529522895813,0.1646512746810913,0.05308699607849121,-0.1578578948974609,-0.241032600402832,-0.08274567127227783,0.0982973575592041,0.1406829357147217,0.02964305877685547,-0.2410472631454468,-0.4467579126358032,-0.3283188343048096,-0.06460404396057129,0.003454446792602539,-0.1611603498458862,-0.3185796737670898,-0.2074989080429077,0.108081579208374,0.2368888854980469,0.03388917446136475,-0.2143336534500122,-0.2674106359481812,-0.1276005506515503,0.07822680473327637,0.1326158046722412,-0.02887570858001709,-0.1712923049926758,-0.1185294389724731,0.07134902477264404,0.2460311651229858,0.2082494497299194,-0.03034257888793945,-0.150377631187439,-0.03596723079681396,0.0875999927520752,0.08413183689117432,0.004613757133483887,-0.03017687797546387,0.05827200412750244,0.1816483736038208,0.2741039991378784,0.4029301404953003,0.5546854734420776,0.6463702917098999,0.5915441513061523,0.313022255897522,-0.05064213275909424,-0.2415366172790527,-0.212932825088501,-0.1200536489486694,-0.1784628629684448,-0.4039599895477295,-0.4744236469268799,-0.2591432332992554,-0.08615684509277344,-0.1691261529922485,-0.343159556388855,-0.3741583824157715,-0.1773122549057007,0.1110485792160034,0.2194739580154419,0.0165332555770874,-0.2918219566345215,-0.3312783241271973,-0.04005336761474609,0.2536083459854126,0.3125864267349243,0.1697571277618408,-0.06330525875091553,-0.2372875213623047,-0.2189503908157349,-0.03149521350860596,0.1348477602005005,0.0906524658203125,-0.102933406829834,-0.197510838508606,-0.116450309753418,0.00506126880645752,0.06338095664978027,0.05020558834075928,-0.03101134300231934,-0.1354979276657104,-0.09590888023376465,0.1748185157775879,0.4400439262390137,0.4145089387893677,0.119340181350708,-0.1699568033218384,-0.1326148509979248,0.2151527404785156,0.407734751701355,0.2006961107254028,-0.09188425540924072,-0.1324330568313599,0.1129705905914307,0.4145616292953491,0.4165040254592896,0.08899331092834473,-0.1633610725402832,-0.1101758480072021,0.02626895904541016,0.02048611640930176,-0.07892298698425293,-0.1619946956634521,-0.1674669981002808,-0.04004025459289551,0.1117981672286987,0.08174371719360352,-0.05476295948028564,-0.04989004135131836,0.09993660449981689,0.2211097478866577,0.2248042821884155,0.1405371427536011,0.04424107074737549,-0.001445770263671875,0.05845892429351807,0.2073330879211426,0.2499990463256836,0.05268371105194092,-0.1793363094329834,-0.1899539232254028,-0.06350958347320557,-0.04883873462677002,-0.1680059432983398,-0.2507184743881226,-0.2150987386703491,-0.1122655868530273,-0.02109766006469727,0.0120232105255127,-0.008169889450073242,-0.09105777740478516,-0.2041001319885254,-0.1424814462661743,0.1729427576065063,0.4264657497406006,0.3270546197891235,-0.00390934944152832,-0.2605403661727905,-0.2720403671264648,-0.1037120819091797,0.01916444301605225,-0.03914928436279297,-0.1650880575180054,-0.1689764261245728,-0.03674685955047607,0.109399676322937,0.1693601608276367,0.1132917404174805,0.02701163291931152,0.01191484928131104,0.03044390678405762,0.05957484245300293,0.1013606786727905,0.01405370235443115,-0.1996012926101685,-0.2946035861968994,-0.2159898281097412,-0.08009803295135498,0.06524550914764404,0.1440156698226929,0.1076799631118774,-0.0006781816482543945,-0.1504948139190674,-0.2813137769699097,-0.3553301095962524,-0.3934570550918579,-0.337297797203064,-0.2171028852462769,-0.2285077571868896,-0.3705674409866333,-0.4488948583602905,-0.4099287986755371,-0.337266206741333,-0.2592229843139648,-0.1487318277359009,-0.0820012092590332,-0.1390244960784912,-0.1574451923370361,0.00406181812286377,0.2200332880020142,0.3902240991592407,0.4517546892166138,0.2780599594116211,0.01981854438781738,-0.01812899112701416,0.08781421184539795,0.07535028457641602,-0.01616525650024414,0.009925603866577148,0.1556134223937988,0.3012768030166626,0.4041397571563721,0.4478093385696411,0.4249507188796997,0.3880394697189331,0.3368754386901855,0.2367888689041138,0.1425437927246094,0.1007754802703857,0.0803835391998291,0.01579940319061279,-0.09983360767364502,-0.1198139190673828,-0.03089296817779541,-0.08177423477172852,-0.2523218393325806,-0.249934196472168,-0.09392631053924561,0.01533377170562744,0.0838245153427124,0.1676679849624634,0.1827361583709717,0.02429640293121338,-0.2165106534957886,-0.3308877944946289,-0.2714163064956665,-0.1213748455047607,-0.02059412002563477,-0.1039358377456665,-0.1875319480895996,0.004454135894775391,0.3080923557281494,0.4141639471054077,0.2457609176635742,-0.1241562366485596,-0.404021143913269,-0.2947505712509155,0.06224250793457031,0.2601799964904785,0.1067949533462524,-0.1804684400558472,-0.242293119430542,-0.07687413692474365,0.02472865581512451,-0.06861042976379395,-0.2418117523193359,-0.2881091833114624,-0.1566803455352783,-0.001857876777648926,0.1346951723098755,0.2682951688766479,0.2768360376358032,0.2028336524963379,0.2271020412445068,0.3025171756744385,0.3013274669647217,0.2292252779006958,0.1468158960342407,0.1093385219573975,0.1420897245407104,0.2409814596176147,0.2944120168685913,0.1235760450363159,-0.1328150033950806,-0.1373885869979858,0.06020188331604004,0.1652683019638062,0.06672656536102295,-0.2043125629425049,-0.4983063936233521,-0.6050100326538086,-0.4789173603057861,-0.202574610710144,0.08358335494995117,0.1923043727874756,0.1257333755493164,0.1063591241836548,0.2191896438598633,0.307252049446106,0.2411777973175049,0.06499612331390381,-0.09615182876586914,-0.1458232402801514,-0.1038968563079834,-0.07611596584320068,-0.0651170015335083,-0.02218365669250488,-0.02847647666931152,-0.09581899642944336,-0.0660099983215332,0.05610132217407227,0.07881009578704834,-0.05660128593444824,-0.250083327293396,-0.3999329805374146,-0.4231054782867432,-0.2603439092636108,-0.001421689987182617,0.1165783405303955,0.03571867942810059,-0.03415501117706299,0.04094839096069336,0.2080754041671753,0.3236416578292847,0.2456369400024414,0.1096161603927612,0.214927077293396,0.501707911491394,0.6588512659072876,0.5708296298980713,0.3424748182296753,0.1950901746749878,0.2485053539276123,0.2915518283843994,0.1066702604293823,-0.1615122556686401,-0.2468421459197998,-0.1274200677871704,-0.04279482364654541,-0.2018293142318726,-0.4932961463928223,-0.6133955717086792,-0.448005199432373,-0.1840804815292358,-0.05060422420501709,-0.026175856590271,0.05864453315734863,0.1902698278427124,0.2329639196395874,0.1796952486038208,0.06511211395263672,-0.07482802867889404,-0.08441257476806641,0.07849466800689697,0.1903930902481079,0.1429105997085571,0.05542290210723877,-0.02004861831665039,-0.07642805576324463,-0.1049871444702148,-0.2362979650497437,-0.4933475255966187,-0.6090748310089111,-0.4773877859115601,-0.3404237031936646,-0.327551007270813,-0.2996311187744141,-0.1972370147705078,-0.1153638362884521,-0.08414757251739502,-0.09330976009368896,-0.1611247062683105,-0.2281222343444824,-0.2192542552947998,-0.1251786947250366,0.02059376239776611,0.04489791393280029,-0.12852942943573,-0.2066968679428101,-0.04369962215423584,0.1649283170700073,0.3548891544342041,0.4334046840667725,0.2857197523117065,0.253606915473938,0.5252652168273926,0.6824694871902466,0.5337096452713013,0.2506482601165771,-0.08748209476470947,-0.3276916742324829,-0.3685921430587769,-0.3211778402328491,-0.1785266399383545,0.01476418972015381,0.05087828636169434,-0.005904436111450195,0.004074215888977051,0.01263427734375,-0.009510397911071777,-0.01485562324523926,-0.008331894874572754,0.04608058929443359,0.1280843019485474,0.1205497980117798,0.03055846691131592,-0.02069091796875,0.01103758811950684,0.0771026611328125,0.1282964944839478,0.1500071287155151,0.1298884153366089,0.06284046173095703,-0.02987301349639893,-0.1060994863510132,-0.09628665447235107,-0.00704038143157959,0.0281221866607666,-0.03167438507080078,-0.074820876121521,-0.04900026321411133,0.01629006862640381,0.09242486953735352,0.1418529748916626,0.1323717832565308,0.04746055603027344,-0.04514265060424805,0.007418155670166016,0.1703091859817505,0.2036617994308472,0.0406649112701416,-0.1332219839096069,-0.1216126680374146,0.06776988506317139,0.1661641597747803,0.00710296630859375,-0.1974161863327026,-0.2408339977264404,-0.1596524715423584,-0.01803958415985107,0.07035696506500244,-0.02882349491119385,-0.1926953792572021,-0.204277515411377,-0.102802038192749,-0.05451869964599609,-0.08975446224212646,-0.121272087097168,-0.1020488739013672,-0.06927919387817383,-0.0324321985244751,0.03092968463897705,0.07179069519042969,0.04960441589355469,0.03531920909881592,0.09091055393218994,0.1458663940429688,0.1191668510437012,0.09352767467498779,0.1694597005844116,0.2479132413864136,0.2118116617202759,0.1022336483001709,-0.01626646518707275,-0.07253777980804443,0.003806114196777344,0.1212379932403564,0.1222341060638428,-0.007488489151000977,-0.1305667161941528,-0.09153318405151367,0.04063796997070312,0.04900956153869629,-0.05875325202941895,-0.1537206172943115,-0.2098701000213623,-0.1620904207229614,-0.0007412433624267578,0.1046510934829712,0.063637375831604,-0.05904841423034668,-0.1504275798797607,-0.1191325187683105,-0.03477466106414795,-0.008606910705566406,-0.02116990089416504,-0.05802285671234131,-0.09378540515899658,-0.05744838714599609,-0.01344656944274902,-0.05574595928192139,-0.1382397413253784,-0.1881105899810791,-0.1704168319702148,-0.1074249744415283,-0.05053317546844482,0.01422417163848877,0.06115877628326416,0.02575838565826416,-0.01965081691741943,0.01464748382568359,0.09755313396453857,0.1309496164321899,0.006529569625854492,-0.224784255027771,-0.3613301515579224,-0.2992352247238159,-0.05887889862060547,0.2011216878890991,0.21478271484375,-0.02547597885131836,-0.2432796955108643,-0.2587541341781616,-0.06875014305114746,0.2133913040161133,0.4195681810379028,0.4800751209259033,0.4067213535308838,0.2546992301940918,0.156377911567688,0.1837936639785767,0.2577930688858032,0.238587498664856,0.06846678256988525,-0.1089508533477783,-0.08616077899932861,0.161676287651062,0.4647667407989502,0.5797772407531738,0.3761752843856812,-0.03111076354980469,-0.3895527124404907,-0.5053867101669312,-0.4028866291046143,-0.2570037841796875,-0.1377131938934326,-0.08002948760986328,-0.1312960386276245,-0.1376439332962036,-0.0205683708190918,0.04053390026092529,0.04432272911071777,0.08341693878173828,0.05740177631378174,-0.03736042976379395,-0.1198649406433105,-0.2088180780410767,-0.2650413513183594,-0.2637424468994141,-0.2349981069564819,-0.1612358093261719,-0.1382968425750732,-0.2348085641860962,-0.3164066076278687,-0.346851110458374,-0.3521409034729004,-0.2998828887939453,-0.3215497732162476,-0.481877326965332,-0.5687128305435181,-0.4409606456756592,-0.1369565725326538,0.1696357727050781,0.2378736734390259,0.1247832775115967,0.09950375556945801,0.2202842235565186,0.3681610822677612,0.3553919792175293,0.0902632474899292,-0.1469783782958984,-0.0530097484588623,0.2558430433273315,0.4901858568191528,0.4814417362213135,0.2659482955932617,0.1120233535766602,0.2083437442779541,0.3833603858947754,0.3574306964874268,0.1195077896118164,-0.06685364246368408,-0.01426398754119873,0.1643931865692139,0.2880669832229614,0.336241602897644,0.3324407339096069,0.2770556211471558,0.2281979322433472,0.2326465845108032,0.2251055240631104,0.1510485410690308,0.1002509593963623,0.1528267860412598,0.2064499855041504,0.17075514793396,0.167772650718689,0.2836860418319702,0.3517180681228638,0.2078907489776611,-0.07735788822174072,-0.3268610239028931,-0.4198759794235229,-0.3559465408325195,-0.2685799598693848,-0.3377618789672852,-0.6061503887176514,-0.8472657203674316,-0.8007203340530396,-0.5500326156616211,-0.3272814750671387,-0.1892877817153931,-0.2225470542907715,-0.4766391515731812,-0.6281954050064087,-0.394871711730957,0.02011585235595703,0.2435745000839233,0.07958686351776123,-0.3093836307525635,-0.4509985446929932,-0.1664084196090698,0.1815509796142578,0.2558580636978149,0.1172753572463989,0.03638029098510742,0.1621286869049072,0.3777341842651367,0.5170478820800781,0.5359145402908325,0.4541053771972656,0.4111322164535522,0.5383607149124146,0.6488698720932007,0.5005522966384888,0.2348159551620483,0.142957329750061,0.2508124113082886,0.3614870309829712,0.3200583457946777,0.1409826278686523,-0.05341613292694092,-0.1133996248245239,0.08169639110565186,0.4398708343505859,0.6107701063156128,0.4138497114181519,0.1179442405700684,0.03515768051147461,0.1499919891357422,0.2484158277511597,0.1358760595321655,-0.1535531282424927,-0.3341513872146606,-0.2947989702224731,-0.2354719638824463,-0.2560433149337769,-0.2664817571640015,-0.2001351118087769,-0.09255564212799072,-0.1024050712585449,-0.2817693948745728,-0.4334940910339355,-0.4849917888641357,-0.5294619798660278,-0.4926570653915405,-0.3412388563156128,-0.2747423648834229,-0.3763788938522339,-0.4748501777648926,-0.4089689254760742,-0.2504125833511353,-0.1969141960144043,-0.2525825500488281,-0.2808315753936768,-0.2518894672393799,-0.1571122407913208,-0.02242422103881836,0.01974117755889893,-0.02113914489746094,-0.02335524559020996,0.01321196556091309,0.08033156394958496,0.1576437950134277,0.1682370901107788,0.1925414800643921,0.3082927465438843,0.3695602416992188,0.3154737949371338,0.2483124732971191,0.2224181890487671,0.2937828302383423,0.4249782562255859,0.4080667495727539,0.2134904861450195,0.05071544647216797,0.05291759967803955,0.1892229318618774,0.2870047092437744,0.1902565956115723,0.03726744651794434,0.0597759485244751,0.2057318687438965,0.2780580520629883,0.218287467956543,0.1348228454589844,0.1491186618804932,0.2072021961212158,0.1936497688293457,0.1449213027954102,0.07997894287109375,-0.09072411060333252,-0.3117305040359497,-0.4040741920471191,-0.3380590677261353,-0.2528179883956909,-0.2643624544143677,-0.30619215965271,-0.223929762840271,-0.05883538722991943,-0.01919114589691162,-0.1330101490020752,-0.1994047164916992,-0.1208701133728027,-0.02180755138397217,0.01465189456939697,0.0691535472869873,0.1903871297836304,0.3001552820205688,0.295025110244751,0.1671932935714722,0.05374240875244141,0.04289102554321289,0.0104902982711792,-0.1508747339248657,-0.3714265823364258,-0.5304889678955078,-0.5005029439926147,-0.2536572217941284,0.01399922370910645,0.126133918762207,0.1128346920013428,0.06847107410430908,0.06730067729949951,0.09963047504425049,0.05929899215698242,-0.03644108772277832,-0.06686770915985107,-0.05743658542633057,-0.0988771915435791,-0.1947883367538452,-0.2950669527053833,-0.2927191257476807,-0.1632838249206543,-0.06753766536712646,-0.06572961807250977,-0.07797610759735107,-0.1418251991271973,-0.2272099256515503,-0.152654767036438,0.03191816806793213,0.1290162801742554,0.1322823762893677,0.08704662322998047,0.005799651145935059,0.008993983268737793,0.2073124647140503,0.4603079557418823,0.4289315938949585,0.09298670291900635,-0.07573950290679932,0.09725916385650635,0.2838695049285889,0.4177829027175903,0.5167337656021118,0.3128827810287476,-0.02532625198364258,-0.01088976860046387,0.2399748563766479,0.3269907236099243,0.1758667230606079,-0.09983134269714355,-0.3012313842773438,-0.3250859975814819,-0.3044943809509277,-0.2931226491928101,-0.2350255250930786,-0.1774222850799561,-0.1395882368087769,-0.08478772640228271,-0.06531822681427002,-0.1275087594985962,-0.1819790601730347,-0.1359711885452271,-0.06845366954803467,-0.03486108779907227,0.0912625789642334,0.2608116865158081,0.2541100978851318,0.1327881813049316,0.06157481670379639,0.0398399829864502,0.07764637470245361,0.1415992975234985,0.1560693979263306,0.1704558134078979,0.1899832487106323,0.1634464263916016,0.09125781059265137,-0.07953739166259766,-0.27559494972229,-0.3020452260971069,-0.2137703895568848,-0.1235111951828003,-0.01520299911499023,0.02361130714416504,-0.0009160041809082031,0.08127248287200928,0.2210766077041626,0.2661761045455933,0.2050405740737915,0.05627703666687012,-0.1016278266906738,-0.1326961517333984,-0.03509962558746338,0.04252243041992188,-0.02240157127380371,-0.1534838676452637,-0.1958211660385132,-0.1515092849731445,-0.08425486087799072,-0.0329740047454834,-0.03377997875213623,-0.01585638523101807,0.05316376686096191,0.06913352012634277,0.058113694190979,0.0986403226852417,0.1530143022537231,0.211927056312561,0.1930581331253052,0.006956696510314941,-0.1426987648010254,-0.09905087947845459,-0.0008691549301147461,0.04855358600616455,0.008612871170043945,-0.08727574348449707,-0.03307783603668213,0.1372717618942261,0.12279212474823,-0.06972730159759521,-0.1965323686599731,-0.182389497756958,-0.06590700149536133,0.06158554553985596,0.06038200855255127,-0.08089947700500488,-0.2539217472076416,-0.3607264757156372,-0.2863476276397705,-0.05159628391265869,0.05647730827331543,-0.04552984237670898,-0.04489398002624512,0.1571617126464844,0.3557990789413452,0.4508157968521118,0.3130313158035278,-0.08681058883666992,-0.3667517900466919,-0.3339323997497559,-0.2119176387786865,-0.06481945514678955,0.05408024787902832,-0.03396522998809814,-0.1653854846954346,-0.1177247762680054,0.004492282867431641,0.1586799621582031,0.3431062698364258,0.3310654163360596,0.06421947479248047,-0.1398375034332275,-0.04394316673278809,0.1914093494415283,0.2431131601333618,0.03007948398590088,-0.2139564752578735,-0.2345342636108398,-0.06131350994110107,0.08063089847564697,0.1097537279129028,0.07638967037200928,0.03491735458374023,0.1086217164993286,0.2349997758865356,0.1388223171234131,-0.07810449600219727,-0.0890965461730957,0.05852532386779785,0.154670238494873,0.07419693470001221,-0.1590657234191895,-0.2311561107635498,-0.03125166893005371,0.147849440574646,0.2062081098556519,0.1575334072113037,-0.07082879543304443,-0.2377492189407349,-0.07712900638580322,0.2325239181518555,0.4088308811187744,0.3564211130142212,0.1815379858016968,0.06384432315826416,-0.02706396579742432,-0.1875236034393311,-0.3315656185150146,-0.3230226039886475,-0.1377565860748291,-0.02615439891815186,-0.2286734580993652,-0.4309282302856445,-0.2789942026138306,0.0334850549697876,0.242511510848999,0.2067620754241943,-0.1077933311462402,-0.3087974786758423,-0.07483720779418945,0.3098561763763428,0.4511663913726807,0.1964614391326904,-0.2777994871139526,-0.4530764818191528,-0.1981769800186157,-0.01883602142333984,-0.1526724100112915,-0.3064099550247192,-0.2607389688491821,-0.07773995399475098,0.06771540641784668,0.04113352298736572,-0.1311202049255371,-0.301460862159729,-0.3492642641067505,-0.2449535131454468,-0.03930449485778809,0.1235213279724121,0.1043952703475952,0.014129638671875,0.09179866313934326,0.3083837032318115,0.4693242311477661,0.5133084058761597,0.4483295679092407,0.3250808715820312,0.2243797779083252,0.123987078666687,0.06512606143951416,0.1627378463745117,0.2262035608291626,0.03954052925109863,-0.1338591575622559,-0.03874266147613525,0.1193627119064331,0.1185134649276733,-0.02080833911895752,-0.1921899318695068,-0.2156863212585449,0.009837150573730469,0.2944798469543457,0.3668310642242432,0.204736590385437,0.02225244045257568,-0.01949858665466309,0.04911911487579346,0.1394107341766357,0.1047636270523071,-0.1848219633102417,-0.5170338153839111,-0.5898450613021851,-0.5017597675323486,-0.4488455057144165,-0.4187421798706055,-0.3615341186523438,-0.2267184257507324,-0.07846951484680176,-0.07898128032684326,-0.1239480972290039,-0.05534303188323975,0.02928531169891357,0.08356106281280518,0.05996215343475342,-0.1523362398147583,-0.2888936996459961,-0.05935609340667725,0.3006564378738403,0.5177173614501953,0.5487066507339478,0.349338173866272,0.1190056800842285,0.2209615707397461,0.5278093814849854,0.5643272399902344,0.2825813293457031,0.0491032600402832,0.02119696140289307,0.05837512016296387,0.01454436779022217,-0.1806247234344482,-0.3899495601654053,-0.3392914533615112,-0.1173803806304932,-0.05301988124847412,-0.1063510179519653,-0.06803047657012939,-0.02016603946685791,-0.09281587600708008,-0.1627397537231445,-0.06523227691650391,0.09327137470245361,0.06693589687347412,-0.1124119758605957,-0.1743266582489014,-0.07012021541595459,-0.05498921871185303,-0.2456456422805786,-0.3817394971847534,-0.2840119600296021,-0.2001874446868896,-0.3210380077362061,-0.4773851633071899,-0.4643367528915405,-0.2019697427749634,0.118611216545105,0.09360373020172119,-0.1947778463363647,-0.3120259046554565,-0.3030194044113159,-0.2243378162384033,0.1890676021575928,0.5271974802017212,0.1636167764663696,-0.2991873025894165,-0.01671862602233887,0.61153244972229,0.8729927539825439,0.7168139219284058,0.3649693727493286,0.1655380725860596,0.3240747451782227,0.4479002952575684,0.2662328481674194,0.09080564975738525,0.02807021141052246,-0.05415236949920654,-0.08115768432617188,-0.1027985811233521,-0.2013791799545288,-0.2058533430099487,-0.1485433578491211,-0.1596337556838989,-0.0322563648223877,0.2720848321914673,0.3880937099456787,0.1651897430419922,-0.103559136390686,-0.03915202617645264,0.3669050931930542,0.6516833305358887,0.4831913709640503,0.1417839527130127,0.0738370418548584,0.2359470129013062,0.2308062314987183,-0.01541984081268311,-0.2119735479354858,-0.2907061576843262,-0.3646119832992554,-0.3273559808731079,-0.1493850946426392,-0.1236417293548584,-0.3369990587234497,-0.4030487537384033,-0.1081593036651611,0.1343815326690674,-0.02106952667236328,-0.224887490272522,-0.1240606307983398,0.09494173526763916,0.2616487741470337,0.3140238523483276,0.0580449104309082,-0.304344654083252,-0.2632330656051636,0.1204818487167358,0.4120384454727173,0.4103450775146484,0.09785914421081543,-0.2689851522445679,-0.3036408424377441,-0.0784299373626709,0.05164229869842529,-0.08606946468353271,-0.4200692176818848,-0.5403561592102051,-0.1904689073562622,0.1667459011077881,0.1246564388275146,-0.05548346042633057,-0.09080660343170166,-0.01428365707397461,0.05890357494354248,0.04537367820739746,-0.02204811573028564,-0.07274293899536133,-0.058998703956604,0.06488347053527832,0.1585805416107178,0.0994415283203125,0.06313741207122803,0.1162625551223755,0.1152592897415161,0.05106270313262939,-0.02955901622772217,-0.08577024936676025,-0.09283304214477539,-0.1175851821899414,-0.07484543323516846,0.1051812171936035,0.1975792646408081,0.1892203092575073,0.2616798877716064,0.3073906898498535,0.313835620880127,0.3943771123886108,0.3318427801132202,0.06860053539276123,-0.02486324310302734,0.1586306095123291,0.2971869707107544,0.1620557308197021,-0.1262048482894897,-0.3278113603591919,-0.3777850866317749,-0.3328670263290405,-0.2697153091430664,-0.2725131511688232,-0.2906416654586792,-0.2335672378540039,-0.1835149526596069,-0.2353404760360718,-0.3352993726730347,-0.3565223217010498,-0.270959734916687,-0.2128084897994995,-0.2126016616821289,-0.1697726249694824,-0.147976279258728,-0.2058056592941284,-0.2312123775482178,-0.1745506525039673,-0.08152604103088379,-0.04900085926055908,-0.09815728664398193,-0.0468590259552002,0.08228528499603271,0.06124711036682129,0.0009199380874633789,0.05161607265472412,0.1119692325592041,0.2260555028915405,0.4260444641113281,0.5175760984420776,0.4005157947540283,0.1484038829803467,0.02315604686737061,0.2724199295043945,0.6194106340408325,0.6287035942077637,0.3634103536605835,0.1433168649673462,0.1300486326217651,0.2184898853302002,0.2210667133331299,0.1837788820266724,0.1903853416442871,0.1751155853271484,0.1374143362045288,0.0623934268951416,-0.08400416374206543,-0.1966497898101807,-0.2473276853561401,-0.2443547248840332,-0.1408510208129883,-0.09799325466156006,-0.2100609540939331,-0.2879394292831421,-0.2974494695663452,-0.3174605369567871,-0.3376108407974243,-0.3824160099029541,-0.3523521423339844,-0.1546167135238647,0.0007586479187011719,-0.02116012573242188,-0.1182938814163208,-0.1843216419219971,-0.1082001924514771,0.05168092250823975,0.1020067930221558,0.07519900798797607,0.0382620096206665,-0.01395583152770996,0.05136561393737793,0.2153842449188232,0.2797610759735107,0.2422873973846436,0.1109251976013184,-0.1436517238616943,-0.2808448076248169,-0.1262625455856323,0.0768502950668335,0.07950139045715332,-0.02425467967987061,-0.03533065319061279,0.05083155632019043,0.09942197799682617,0.01042580604553223,-0.2126635313034058,-0.3881356716156006,-0.3023363351821899,-0.02879834175109863,0.2078820466995239,0.298514723777771,0.1654778718948364,-0.1312090158462524,-0.2547134160995483,-0.04121661186218262,0.2254713773727417,0.2809914350509644,0.200359582901001,0.1482110023498535,0.1545373201370239,0.1396602392196655,0.06464946269989014,0.06197690963745117,0.2096240520477295,0.2707948684692383,0.07253873348236084,-0.1603716611862183,-0.2010895013809204,-0.1024580001831055,-0.02319943904876709,-0.07739388942718506,-0.2191925048828125,-0.3020814657211304,-0.2741478681564331,-0.1497834920883179,-0.03595638275146484,-0.09832310676574707,-0.224236011505127,-0.1643894910812378,0.04751253128051758,0.2462636232376099,0.3196178674697876,0.2029056549072266,0.01961243152618408,-0.02134764194488525,0.1338458061218262,0.3607368469238281,0.4180318117141724,0.2170532941818237,-0.03498828411102295,-0.1107209920883179,0.07091879844665527,0.3364086151123047,0.3142569065093994,0.01926779747009277,-0.1566542387008667,-0.1686663627624512,-0.2309702634811401,-0.330588698387146,-0.3840150833129883,-0.4107537269592285,-0.4007214307785034,-0.2764230966567993,-0.05582690238952637,0.04983091354370117,-0.05813241004943848,-0.1726377010345459,-0.1218671798706055,0.07038629055023193,0.2753010988235474,0.2729107141494751,0.05687510967254639,-0.0331263542175293,0.1520801782608032,0.3271195888519287,0.237299919128418,-0.00990605354309082,-0.1496646404266357,-0.06875181198120117,0.1384432315826416,0.2152771949768066,-0.002272605895996094,-0.2090256214141846,-0.0466911792755127,0.2346700429916382,0.2915723323822021,0.2392052412033081,0.1811915636062622,0.08992576599121094,0.09091806411743164,0.1858981847763062,0.1912738084793091,0.09656059741973877,-0.02570414543151855,-0.1338851451873779,-0.08350980281829834,0.1206663846969604,0.1912846565246582,0.02777040004730225,-0.1716281175613403,-0.2610994577407837,-0.1915425062179565,-0.02524852752685547,0.03601193428039551,-0.05808186531066895,-0.2141437530517578,-0.3590340614318848,-0.2858556509017944,0.008411884307861328,0.08953189849853516,-0.1361392736434937,-0.3051102161407471,-0.2923240661621094,-0.1212154626846313,0.105876088142395,0.07384288311004639,-0.1059069633483887,-0.004046440124511719,0.1914026737213135,0.1206933259963989,-0.02849364280700684,-0.08770573139190674,-0.1297378540039062,-0.05654644966125488,0.1731386184692383,0.3246288299560547,0.236175537109375,-0.04656469821929932,-0.3059722185134888,-0.2351882457733154,0.1076450347900391,0.3063905239105225,0.2175294160842896,-0.06352424621582031,-0.4193892478942871,-0.4660284519195557,-0.06457579135894775,0.2440205812454224,0.1759666204452515,0.06360423564910889,0.1085140705108643,0.2737370729446411,0.4618967771530151,0.4798510074615479,0.2650065422058105,-0.07675707340240479,-0.3602497577667236,-0.3679012060165405,-0.1707658767700195,-0.01599383354187012,0.03636372089385986,-0.08846127986907959,-0.4080536365509033,-0.6260230541229248,-0.5455138683319092,-0.3190462589263916,-0.2108305692672729,-0.3248975276947021,-0.4368152618408203,-0.3799185752868652,-0.2674049139022827,-0.0724177360534668,0.1397222280502319,0.05809104442596436,-0.09805262088775635,0.1061332225799561,0.4166985750198364,0.4906672239303589,0.4173665046691895,0.2580958604812622,0.08837234973907471,0.07400417327880859,0.123368501663208,0.1234176158905029,0.186764121055603,0.2682111263275146,0.1812236309051514,-0.0349191427230835,-0.2522264719009399,-0.3966332674026489,-0.369682788848877,-0.235249400138855,-0.1583970785140991,-0.07498633861541748,0.07243096828460693,0.1760516166687012,0.2760255336761475,0.3906028270721436,0.3499257564544678,0.1932424306869507,0.129162073135376,0.2226176261901855,0.4442315101623535,0.6010656356811523,0.4179006814956665,0.01513075828552246,-0.132709264755249,0.1757354736328125,0.5732526779174805,0.6026928424835205,0.3467355966567993,0.2107197046279907,0.2742569446563721,0.2815423011779785,0.09001171588897705,-0.1057474613189697,-0.0814361572265625,0.00655663013458252,-0.09407532215118408,-0.3088316917419434,-0.4156311750411987,-0.2907394170761108,-0.07655751705169678,-0.1094914674758911,-0.3572696447372437,-0.4917538166046143,-0.513567328453064,-0.5608114004135132,-0.5864546298980713,-0.540798544883728,-0.404321551322937,-0.2458362579345703,-0.1961888074874878,-0.1791560649871826,-0.1205170154571533,-0.1216897964477539,-0.1582927703857422,-0.1537785530090332,-0.12968909740448,-0.07600569725036621,-0.03156530857086182,-0.02151548862457275,0.04917049407958984,0.1404664516448975,0.1671479940414429,0.2159342765808105,0.270550012588501,0.1838304996490479,0.001464247703552246,-0.03464090824127197,0.2091317176818848,0.5141391754150391,0.5977417230606079,0.5036834478378296,0.3247849941253662,0.1000516414642334,0.06908547878265381,0.2511162757873535,0.2727469205856323,0.0390322208404541,-0.2012205123901367,-0.2688493728637695,-0.1277774572372437,0.006447792053222656,-0.1149201393127441,-0.2898036241531372,-0.1936162710189819,0.1109970808029175,0.3694965839385986,0.4097951650619507,0.2495013475418091,0.0932086706161499,0.08410525321960449,0.1603349447250366,0.1431025266647339,-0.06237399578094482,-0.308557391166687,-0.4572519063949585,-0.534740686416626,-0.4591219425201416,-0.2162871360778809,-0.06452071666717529,-0.0532451868057251,0.008758544921875,0.08639848232269287,0.01289999485015869,-0.2439701557159424,-0.4854593276977539,-0.4025264978408813,-0.07280445098876953,0.1244490146636963,0.1279217004776001,0.06558895111083984,-0.04457271099090576,-0.0866553783416748,0.08774614334106445,0.33073890209198,0.2727041244506836,-0.1197576522827148,-0.331241250038147,-0.09236383438110352,0.2290890216827393,0.311805248260498,0.1072354316711426,-0.2255498170852661,-0.2621369361877441,0.03795421123504639,0.2442004680633545,0.2530041933059692,0.1400517225265503,-0.06605613231658936,-0.1149649620056152,0.02216565608978271,0.09705841541290283,0.05669069290161133,-0.177857518196106,-0.4909087419509888,-0.3668278455734253,0.1626386642456055,0.4745478630065918,0.3136841058731079,-0.1015360355377197,-0.3500828742980957,-0.1896252632141113,0.08188807964324951,0.1658613681793213,0.168404221534729,0.19347083568573,0.2105270624160767,0.2301465272903442,0.3087074756622314,0.3862107992172241,0.2878037691116333,0.1319364309310913,0.1468095779418945,0.1175373792648315,-0.08168137073516846,-0.1999015808105469,-0.297898530960083,-0.5145112276077271,-0.6112810373306274,-0.526374340057373,-0.4529399871826172,-0.3701727390289307,-0.1749911308288574,0.06059420108795166,0.1851898431777954,0.1287882328033447,-0.05832624435424805,-0.2162488698959351,-0.1700676679611206,0.02939319610595703,0.2303057909011841,0.3751944303512573,0.2530359029769897,-0.09894645214080811,-0.09208893775939941,0.2618454694747925,0.2894704341888428,-0.005408048629760742,-0.180842399597168,-0.1171609163284302,0.07984566688537598,0.1354296207427979,0.05776631832122803,0.09128844738006592,0.003483414649963379,-0.1658855676651001,0.1222798824310303,0.574099063873291,0.5420286655426025,0.09852564334869385,-0.3991636037826538,-0.4728732109069824,0.02536845207214355,0.3650059700012207,0.09725570678710938,-0.354050874710083,-0.5423804521560669,-0.3158066272735596,0.09866905212402344,0.3257391452789307,0.3380483388900757,0.1648119688034058,-0.06589663028717041,-0.005535364151000977,0.2234407663345337,0.3650290966033936,0.5075560808181763,0.4379557371139526,0.04190909862518311,-0.246584415435791,-0.2685767412185669,-0.1407252550125122,0.01032125949859619,-0.07430493831634521,-0.2047638893127441,-0.06399881839752197,0.01855230331420898,-0.05833053588867188,0.0870816707611084,0.3238606452941895,0.2781710624694824,0.05839824676513672,0.01467788219451904,0.2466961145401001,0.4157226085662842,0.2202436923980713,-0.08820176124572754,-0.1249254941940308,0.07479095458984375,0.1984701156616211,0.07612299919128418,-0.2053008079528809,-0.5070878267288208,-0.6201440095901489,-0.383338451385498,-0.1232089996337891,-0.1525936126708984,-0.1547191143035889,0.02612876892089844,0.07290172576904297,0.01150619983673096,0.08259415626525879,0.1732279062271118,0.1360905170440674,0.07001960277557373,0.0677264928817749,0.08392584323883057,0.09935843944549561,0.1691534519195557,0.2037128210067749,0.08412182331085205,-0.02535104751586914,0.01034379005432129,0.02763664722442627,-0.04409396648406982,-0.0974733829498291,-0.154589056968689,-0.2672826051712036,-0.3448765277862549,-0.3025083541870117,-0.1466963291168213,0.02436184883117676,0.02073192596435547,-0.1876888275146484,-0.3431856632232666,-0.2659716606140137,-0.05633389949798584,0.06944596767425537,-0.07357847690582275,-0.3485486507415771,-0.3663941621780396,-0.1412132978439331,0.02192676067352295,0.06795299053192139,-0.03778767585754395,-0.267574667930603,-0.2983218431472778,-0.1155807971954346,-0.04213368892669678,-0.1048632860183716,-0.2037041187286377,-0.2666642665863037,-0.1799485683441162,-0.09489858150482178,-0.1226378679275513,-0.03282153606414795,0.1667155027389526,0.2886523008346558,0.3630998134613037,0.3533258438110352,0.2875798940658569,0.362109899520874,0.4237382411956787,0.257606029510498,0.02316927909851074,-0.1640040874481201,-0.2374862432479858,-0.05503332614898682,0.1878509521484375,0.1553405523300171,-0.1380592584609985,-0.3988516330718994,-0.2691837549209595,0.2116876840591431,0.4677320718765259,0.2583783864974976,-0.02291691303253174,-0.04464042186737061,0.2076374292373657,0.4418939352035522,0.3122760057449341,0.07548320293426514,0.1544861793518066,0.2907305955886841,0.183924674987793,0.03944432735443115,0.0003529787063598633,0.02513432502746582,0.06838536262512207,0.04999363422393799,0.03568756580352783,0.04300582408905029,-0.1131632328033447,-0.2225935459136963,0.07981491088867188,0.4349994659423828,0.3670787811279297,0.1160695552825928,0.00928795337677002,-0.0004462003707885742,0.02746880054473877,0.03491628170013428,-0.08943116664886475,-0.261937141418457,-0.3551846742630005,-0.3928669691085815,-0.3184946775436401,-0.1534903049468994,-0.2064709663391113,-0.4494235515594482,-0.4161912202835083,-0.06952106952667236,0.2255375385284424,0.2758200168609619,-0.003589153289794922,-0.3786740303039551,-0.324907660484314,0.06911289691925049,0.3133480548858643,0.3564351797103882,0.1808688640594482,-0.1900404691696167,-0.2282946109771729,0.1859099864959717,0.495044469833374,0.5594632625579834,0.4981580972671509,0.1521062850952148,-0.3257222175598145,-0.4984486103057861,-0.3790597915649414,-0.355160117149353,-0.5539252758026123,-0.6199431419372559,-0.3096261024475098,0.09151041507720947,0.2860305309295654,0.217833399772644,-0.03003263473510742,-0.1501905918121338,-0.0435868501663208,0.1055201292037964,0.3207576274871826,0.3784443140029907,0.002088785171508789,-0.1650339365005493,0.3326765298843384,0.7373538017272949,0.4136694669723511,-0.2593897581100464,-0.3962743282318115,0.2137050628662109,0.5084832906723022,0.02224278450012207,-0.309739351272583,-0.2930746078491211,-0.3677979707717896,-0.2049554586410522,0.2149406671524048,0.3957346677780151,0.2298036813735962,-0.2921645641326904,-0.6442588567733765,-0.06464838981628418,0.6657575368881226,0.3438237905502319,-0.5114223957061768,-0.7565821409225464,-0.2288784980773926,0.4605927467346191,0.6707718372344971,0.2714297771453857,-0.3244245052337646,-0.542393684387207,-0.1905463933944702,0.3469411134719849,0.6017332077026367,0.287980318069458,-0.4087978601455688,-0.574027419090271,0.134032130241394,0.7715094089508057,0.5865850448608398,-0.1838314533233643,-0.6265971660614014,-0.1741892099380493,0.1575719118118286,-0.4227795600891113,-0.7438890933990479,-0.1558103561401367,0.4590085744857788,0.4941010475158691,-0.1008820533752441,-0.6578335762023926,-0.3708750009536743,0.1586992740631104,0.3995285034179688,0.6163557767868042,0.2457789182662964,-0.5310143232345581,-0.360217809677124,0.2878856658935547,0.2612651586532593,-0.0309150218963623,-0.1899121999740601,-0.2283810377120972,-0.06510829925537109,-0.08580231666564941,-0.1838128566741943,0.2295181751251221,0.6024744510650635,0.2225643396377563,-0.372930645942688,-0.3810786008834839,0.2628804445266724,0.838129997253418,0.6153090000152588,-0.1111502647399902,-0.5334081649780273,-0.3915431499481201,0.06813228130340576,0.324732780456543,-0.04104757308959961,-0.6423393487930298,-0.7318356037139893,-0.2643457651138306,0.3520128726959229,0.7881782054901123,0.6005949974060059,-0.2200359106063843,-0.6831574440002441,-0.1151156425476074,0.7360175848007202,0.7609043121337891,0.0198591947555542,-0.282761812210083,0.2536827325820923,0.3645209074020386,-0.3862451314926147,-0.6231451034545898,0.118194580078125,0.7322566509246826,0.5195361375808716,-0.2600194215774536,-0.8326712846755981,-0.6319019794464111,0.03485608100891113,0.5860122442245483,0.574150562286377,-0.1529425382614136,-0.7133954763412476,-0.2712798118591309,0.4954695701599121,0.6345229148864746,0.0676649808883667,-0.6211779117584229,-0.5474170446395874,0.2571253776550293,0.7518115043640137,0.5120896100997925,-0.2344119548797607,-0.8866300582885742,-0.4470227956771851,0.5884546041488647,0.5169771909713745,-0.4819290637969971,-0.9784841537475586,-0.7711467742919922,-0.3285106420516968,0.09146761894226074,0.3199635744094849,0.412663459777832,0.4059092998504639,0.2785141468048096,0.1306002140045166,-0.05022239685058594,-0.007319211959838867,0.5039563179016113,0.6705232858657837,-0.03055930137634277,-0.5351643562316895,-0.138258695602417,0.4127510786056519,0.3909457921981812,-0.0986785888671875,-0.5764031410217285,-0.7296823263168335,-0.3905185461044312,0.4485559463500977,0.9723082780838013,0.4026216268539429,-0.5567766427993774,-0.9455606937408447,-0.6657295227050781,0.06130516529083252,0.4886423349380493,0.08493590354919434,-0.4022452831268311,-0.4323420524597168,-0.2828390598297119,-0.0103679895401001,0.2499899864196777,0.2023454904556274,-0.1718641519546509,-0.6598156690597534,-0.656002402305603,-0.06048738956451416,0.3633211851119995,0.4799891710281372,0.354764461517334,-0.2149626016616821,-0.3000049591064453,0.5490376949310303,0.8137855529785156,-0.06708705425262451,-0.7318167686462402,-0.3656480312347412,0.4330126047134399,0.7128390073776245,0.3522260189056396,-0.1665608882904053,-0.5695223808288574,-0.4583829641342163,0.177033543586731,0.6026372909545898,0.6689604520797729,0.3397685289382935,-0.5194952487945557,-0.6779452562332153,0.292144775390625,0.6452754735946655,-0.01945638656616211,-0.4859579801559448,-0.4184466600418091,0.0697706937789917,0.5434660911560059,0.3654745817184448,0.03404450416564941,-0.05743277072906494,-0.4075822830200195,-0.6141712665557861,-0.06219184398651123,0.5235365629196167,0.3879885673522949,-0.1991713047027588,-0.5489438772201538,-0.2341669797897339,0.4552555084228516,0.7555826902389526,0.3049860000610352,-0.4351241588592529,-0.6865565776824951,-0.2479285001754761,0.3605800867080688,0.4563146829605103,-0.1433135271072388,-0.6370787620544434,-0.2331945896148682,0.4545891284942627,0.4741203784942627,-0.05249416828155518,-0.5524971485137939,-0.5570087432861328,0.02463424205780029,0.5852054357528687,0.7101272344589233,0.4389029741287231,-0.2066934108734131,-0.5219568014144897,-0.02491378784179688,0.1399203538894653,-0.4414293766021729,-0.4116953611373901,0.4619160890579224,0.9384205341339111,0.4579236507415771,-0.2996025085449219,-0.2126563787460327,0.5504779815673828,0.5747339725494385,-0.1491687297821045,-0.4231275320053101,-0.1321370601654053,0.1955393552780151,0.2291048765182495,-0.1937917470932007,-0.5427207946777344,-0.2729601860046387,0.086586594581604,-0.1143324375152588,-0.4827606678009033,-0.3443067073822021,0.05683755874633789,0.04019927978515625,-0.2613890171051025,-0.2557828426361084,0.07833290100097656,0.3340630531311035,0.2017322778701782,-0.1654154062271118,-0.2285248041152954,0.06349706649780273,0.1870832443237305,-0.006801843643188477,-0.1902040243148804,-0.1360678672790527,0.07556819915771484,0.1783308982849121,0.05229449272155762,-0.1417117118835449,-0.2288943529129028,-0.1711263656616211,-0.04217255115509033,0.04537904262542725,0.06950473785400391,0.03894948959350586,-0.02073013782501221,0.04717051982879639,0.2333457469940186,0.2253497838973999,-0.006310462951660156,-0.1150127649307251,-0.008890032768249512,0.1111550331115723,0.1408828496932983,0.08908164501190186,0.005650877952575684,-0.02553880214691162,0.02351582050323486,0.06732261180877686,0.0314333438873291,0.01989114284515381,0.09762609004974365,0.08297169208526611,-0.06661117076873779,-0.1224530935287476,-0.008718252182006836,0.1274261474609375,0.1190932989120483,-0.06444311141967773,-0.2041544914245605,-0.1305084228515625,0.02326321601867676,0.07358145713806152,-0.01998293399810791,-0.1172645092010498,-0.04380154609680176,0.07770586013793945,0.050850510597229,-0.01305079460144043,0.01223087310791016,0.05276322364807129,0.03322410583496094,-0.04061412811279297,-0.07350432872772217,-0.0009435415267944336,0.07046008110046387,0.06146383285522461,0.01407003402709961,-0.0234062671661377,0.006303548812866211,0.05606412887573242,0.01598381996154785,-0.01992392539978027,0.02043497562408447,0.01262509822845459,-0.0258098840713501,-0.004443645477294922,0.009035706520080566,-0.01651155948638916,-0.04862606525421143,-0.06282889842987061,-0.01059722900390625,0.0404738187789917,0.01205539703369141,-0.006382226943969727,-0.009562969207763672,-0.06385922431945801,-0.05755174160003662,0.05746328830718994,0.1134049892425537,0.04133987426757812,-0.03484165668487549,-0.02540123462677002,0.0326530933380127,0.06372570991516113,0.03755974769592285,-0.002273917198181152,0.007511019706726074,0.03771567344665527,0.01308107376098633,-0.03845572471618652,-0.02448439598083496,0.06008768081665039,0.09114634990692139,-0.01603615283966064,-0.1075561046600342,-0.03599035739898682,0.05264782905578613,0.03523433208465576,0.002344369888305664,-0.02453136444091797,-0.05310750007629395,-0.01263713836669922,0.03991496562957764,0.02198922634124756,0.004774570465087891,0.008779048919677734,0.0001819133758544922,0.002903461456298828,-0.006437778472900391,-0.03244709968566895,-0.002589941024780273,0.03927433490753174,0.01921379566192627,-0.02771234512329102,-0.07695841789245605,-0.08425664901733398,-0.0177915096282959,0.02859354019165039,-0.00383448600769043,-0.03840339183807373,-0.02123427391052246,0.0147322416305542,0.03922522068023682,0.06281805038452148,0.06939005851745605,0.01897537708282471,-0.0309525728225708,-0.007551074028015137,0.02358949184417725,0.01169002056121826,0.01900863647460938,0.04643332958221436,0.02167582511901855,-0.03310239315032959,-0.02425789833068848,0.03391182422637939,0.02909505367279053,-0.04286181926727295,-0.08227348327636719,-0.05507934093475342,0.02338707447052002,0.1082500219345093,0.1097118854522705,0.04321134090423584,0.01282119750976562,0.02327585220336914,0.04160892963409424,0.05429244041442871,-0.004351973533630371,-0.1254899501800537,-0.1631848812103271,-0.05348420143127441,0.08572709560394287,0.1139974594116211,0.04638862609863281,0.02370572090148926,0.08640837669372559,0.1312609910964966,0.1177380084991455,0.09749054908752441,0.05930495262145996,-0.02617132663726807,-0.08287572860717773,-0.05668902397155762,-0.03946197032928467,-0.09245908260345459,-0.1361583471298218,-0.1266753673553467,-0.1201940774917603,-0.1109322309494019,-0.0006064176559448242,0.2017041444778442,0.2879583835601807,0.1232911348342896,-0.1048469543457031,-0.1258960962295532,0.03835964202880859,0.1044571399688721,-0.07197606563568115,-0.2463558912277222,-0.1602014303207397,0.02674484252929688,0.04983580112457275,-0.08300471305847168,-0.2294007539749146,-0.2219077348709106,-0.004956483840942383,0.1775838136672974,0.1174869537353516,-0.04721701145172119,-0.09616315364837646,0.05314850807189941,0.2944717407226562,0.3705202341079712,0.2033307552337646,0.02420806884765625,0.0520251989364624,0.2128645181655884,0.2073276042938232,-0.05738413333892822,-0.2889090776443481,-0.2896708250045776,-0.183765172958374,-0.1275899410247803,-0.1949390172958374,-0.2825204133987427,-0.1559693813323975,0.1101024150848389,0.2054411172866821,0.115270733833313,0.06059503555297852,0.1388167142868042,0.2539017200469971,0.2276045083999634,0.01439690589904785,-0.2176473140716553,-0.2718672752380371,-0.151907205581665,-0.07214510440826416,-0.1105411052703857,-0.1115560531616211,-0.08550834655761719,-0.1326000690460205,-0.1313234567642212,-0.05478334426879883,-0.03540182113647461,-0.0252687931060791,0.07521796226501465,0.2689557075500488,0.4555709362030029,0.3811008930206299,0.06534028053283691,-0.08026134967803955,0.07174909114837646,0.2229506969451904,0.08963119983673096,-0.2792134284973145,-0.4089596271514893,-0.1243742704391479,0.02197813987731934,-0.1902068853378296,-0.3446252346038818,-0.3159257173538208,-0.1423581838607788,0.2947663068771362,0.7362929582595825,0.7750861644744873,0.4563534259796143,0.06938302516937256,-0.1383017301559448,-0.1167263984680176,-0.07243108749389648,-0.1530411243438721,-0.3028267621994019,-0.367592453956604,-0.2132271528244019,0.007699728012084961,0.02527034282684326,-0.1072838306427002,-0.2266958951950073,-0.2243047952651978,0.0656425952911377,0.4627550840377808,0.5403631925582886,0.3466042280197144,0.11385178565979,-0.127671480178833,-0.184709906578064,-0.02491199970245361,-0.01671338081359863,-0.1721980571746826,-0.1982072591781616,-0.1221086978912354,-0.09194684028625488,-0.1459124088287354,-0.2005194425582886,-0.141629695892334,-0.1771457195281982,-0.385184645652771,-0.2657450437545776,0.2853555679321289,0.6377096176147461,0.4454507827758789,-0.001583456993103027,-0.1645478010177612,0.1150424480438232,0.2387080192565918,-0.132733941078186,-0.4081352949142456,-0.2257047891616821,0.04004859924316406,0.1099059581756592,0.07300472259521484,0.08724629878997803,0.1413506269454956,0.1508340835571289,0.2560392618179321,0.390465259552002,0.128954291343689,-0.3180372714996338,-0.3232216835021973,-0.03866112232208252,0.08037316799163818,0.008283019065856934,-0.1810308694839478,-0.2661529779434204,-0.01974248886108398,0.2116917371749878,0.04902803897857666,-0.2370178699493408,-0.2732540369033813,-0.09414970874786377,0.1213197708129883,0.2410464286804199,0.09976482391357422,-0.232689380645752,-0.2742420434951782,0.1354876756668091,0.4791984558105469,0.4685813188552856,0.3172694444656372,0.05891680717468262,-0.3305113315582275,-0.4748817682266235,-0.09956049919128418,0.3169574737548828,0.09677433967590332,-0.456674337387085,-0.4429486989974976,0.04047000408172607,0.1828142404556274,-0.008448600769042969,-0.04650223255157471,0.02262473106384277,0.05692887306213379,0.2104408740997314,0.504439115524292,0.6613615751266479,0.3588534593582153,-0.3096740245819092,-0.7301636934280396,-0.5324171781539917,-0.1014124155044556,-0.07029604911804199,-0.4780963659286499,-0.5786560773849487,-0.02146494388580322,0.4540152549743652,0.3691476583480835,0.146000862121582,0.09157788753509521,0.1823413372039795,0.3059607744216919,0.2531864643096924,0.09471821784973145,0.0314486026763916,-0.001305937767028809,-0.06814372539520264,-0.1639068126678467,-0.201518177986145,-0.04265928268432617,0.04594480991363525,-0.1618025302886963,-0.2416727542877197,0.0335390567779541,0.2772445678710938,0.2273392677307129,-0.006441950798034668,-0.17177414894104,-0.1300084590911865,-0.01907610893249512,0.008104920387268066,-0.002175331115722656,0.02631831169128418,0.06667470932006836,0.04570567607879639,-0.02721428871154785,-0.06315267086029053,-0.03280854225158691,0.02458071708679199,0.05125510692596436,0.02595829963684082,0.02135384082794189,0.05609500408172607,0.04636752605438232,0.004126787185668945,-0.01322281360626221,-0.02950763702392578,-0.03713393211364746,-0.01638162136077881,-0.01133346557617188,-0.01664018630981445,-0.002984285354614258,-0.003911256790161133,-0.009224414825439453,0.01479244232177734,0.01785087585449219,-0.01871681213378906,-0.03130793571472168,-0.01453578472137451,-0.01931393146514893,-0.03905999660491943,-0.02290940284729004]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"fft filter output"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"threshold"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>150</value></param>
<param><key>ymin</key><value>-150</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
