<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xcorr_tester</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_mic_offset</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d1</value></param>
<param><key>value</key><value>-32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d2</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d3</value></param>
<param><key>value</key><value>-32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>astra_xcorr_ts_ff</key>
<param><key>id</key><value>astra_xcorr_ts_ff_0</value></param>
<param><key>ip_address</key><value>127.0.0.1</value></param>
<param><key>center_mic_offset</key><value>center_mic_offset</value></param>
<param><key>node_number</key><value>1</value></param>
<param><key>port_num</key><value>5555</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_window</key><value>5000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>plughw:2,0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>center_mic_offset+d2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>center_mic_offset+d3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>delay</key><value>center_mic_offset+d1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>1</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>1</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0.007661581039428711,0.00752556324005127,0.00622856616973877,0.004907608032226562,0.002756118774414062,0.0009366273880004883,-0.0006685256958007812,-0.00184786319732666,-0.003353357315063477,-0.005064725875854492,-0.0059356689453125,-0.005124211311340332,-0.002981185913085938,-0.0007177591323852539,0.0006318092346191406,0.001436114311218262,0.002619266510009766,0.003385305404663086,0.00426638126373291,0.00455319881439209,0.004121780395507812,0.002879142761230469,0.001756906509399414,0.001510143280029297,0.002755165100097656,0.00445246696472168,0.005632162094116211,0.006775975227355957,0.007596254348754883,0.008538246154785156,0.008727550506591797,0.007706046104431152,0.005002140998840332,0.002144336700439453,-0.0001677274703979492,-0.001613497734069824,-0.001983046531677246,-0.001582503318786621,-0.001252293586730957,-0.0004506111145019531,0.0005199909210205078,0.0006850957870483398,0.000630497932434082,0.0005941390991210938,0.0004419088363647461,0.0001071691513061523,0.0001406669616699219,-8.738040924072266e-05,-0.001126885414123535,-0.002161622047424316,-0.002627968788146973,-0.002823829650878906,-0.003040432929992676,-0.002264499664306641,-0.0005069971084594727,0.001303791999816895,0.002311825752258301,0.002084493637084961,0.00191807746887207,0.002656936645507812,0.00411379337310791,0.00536811351776123,0.005843400955200195,0.00567781925201416,0.005724072456359863,0.005869150161743164,0.005816102027893066,0.004889845848083496,0.003304243087768555,0.001100897789001465,-0.001069068908691406,-0.002793312072753906,-0.004145979881286621,-0.005073904991149902,-0.004506587982177734,-0.003137350082397461,-0.002463936805725098,-0.001960277557373047,-0.002410769462585449,-0.003127336502075195,-0.002952456474304199,-0.001300692558288574,0.0003833770751953125,0.0009677410125732422,0.001103520393371582,0.001332402229309082,0.002486586570739746,0.004593610763549805,0.005479812622070312,0.004653811454772949,0.003659367561340332,0.003383636474609375,0.003495931625366211,0.003583908081054688,0.003313302993774414,0.003092169761657715,0.003312826156616211,0.003733277320861816,0.003450512886047363,0.002473950386047363,0.001115322113037109,-0.0001949071884155273,-0.001544475555419922,-0.00201725959777832,-0.001910924911499023,-0.00203704833984375,-0.00257718563079834,-0.00241541862487793,-0.001410722732543945,0.0009194612503051758,0.004051327705383301,0.004827976226806641,0.003462910652160645,0.001897811889648438,0.0007274150848388672,-0.0003095865249633789,-0.0002840757369995117,0.0002585649490356445,0.0004101991653442383,-0.0002609491348266602,-0.0001178979873657227,0.0007276535034179688,0.001865148544311523,0.002255797386169434,0.0004867315292358398,-0.00153648853302002,-0.002768993377685547,-0.002959728240966797,-0.002346992492675781,-0.00245976448059082,-0.004342555999755859,-0.006069064140319824,-0.006183147430419922,-0.004430532455444336,-0.001982569694519043,0.0003261566162109375,0.001268267631530762,0.001345992088317871,0.001713752746582031,0.002066254615783691,0.002494096755981445,0.003243565559387207,0.00404655933380127,0.003504753112792969,0.002282023429870605,0.002361297607421875,0.004312872886657715,0.006111025810241699,0.005878448486328125,0.003670811653137207,0.0006158351898193359,-0.001653432846069336,-0.002578616142272949,-0.002697467803955078,-0.00276637077331543,-0.00262606143951416,-0.003180384635925293,-0.003061413764953613,-0.001652240753173828,0.0008715391159057617,0.002104759216308594,0.002261996269226074,0.001766681671142578,0.001682877540588379,0.002151012420654297,0.002850055694580078,0.003459572792053223,0.004484295845031738,0.005202651023864746,0.005409836769104004,0.005925655364990234,0.006084203720092773,0.005953073501586914,0.006226420402526855,0.005828738212585449,0.004209280014038086,0.003028154373168945,0.002286672592163086,0.00130915641784668,-0.0005435943603515625,-0.002394437789916992,-0.002192258834838867,-0.0007456541061401367,0.0003156661987304688,-0.0004186630249023438,-0.001706361770629883,-0.002317070960998535,-0.0008810758590698242,0.001416802406311035,0.003204703330993652,0.003718376159667969,0.003610610961914062,0.003693103790283203,0.003859162330627441,0.004644513130187988,0.005517840385437012,0.005786299705505371,0.005223989486694336,0.004219532012939453,0.002425789833068848,0.001176357269287109,0.0004857778549194336,-0.0005521774291992188,-0.00154721736907959,-0.00188136100769043,-0.001198291778564453,-9.810924530029297e-05,0.0008552074432373047,0.001701116561889648,0.001911640167236328,0.002021551132202148,0.00235438346862793,0.002172231674194336,0.002496242523193359,0.00266563892364502,0.001989483833312988,-2.431869506835938e-05,-0.00227665901184082,-0.003401279449462891,-0.002821803092956543,-0.0007337331771850586,0.0009139776229858398,0.001326560974121094,0.001567840576171875,0.001958370208740234,0.001595973968505859,0.001073718070983887,0.001272797584533691,0.000994563102722168,0.0005435943603515625,0.0002820491790771484,0.0003615617752075195,0.001481294631958008,0.003549575805664062,0.005357861518859863,0.006720185279846191,0.006980061531066895,0.006814956665039062,0.006338596343994141,0.005135536193847656,0.002874970436096191,-0.0005993843078613281,-0.003754258155822754,-0.004482865333557129,-0.003475189208984375,-0.002315998077392578,-0.0007908344268798828,0.0009212493896484375,0.002312064170837402,0.003865242004394531,0.00502479076385498,0.005324482917785645,0.004297137260437012,0.003341913223266602,0.002001047134399414,-0.000201106071472168,-0.002058029174804688,-0.003791332244873047,-0.004540205001831055,-0.004213690757751465,-0.002625942230224609,-0.001363396644592285,-0.0009788274765014648,-0.0002464056015014648,0.001933693885803223,0.004602551460266113,0.006688356399536133,0.006116151809692383,0.00336766242980957,0.0005431175231933594,-0.001073837280273438,-0.001187801361083984,-0.001543045043945312,-0.003156304359436035,-0.004740118980407715,-0.004511117935180664,-0.002816915512084961,-0.0008656978607177734,0.00170135498046875,0.00410914421081543,0.005897641181945801,0.007529258728027344,0.007628798484802246,0.005872130393981934,0.002620577812194824,-0.0007470846176147461,-0.00450587272644043,-0.007375359535217285,-0.008608698844909668,-0.008328676223754883,-0.006817936897277832,-0.004534482955932617,-0.001901984214782715,0.001051068305969238,0.004233717918395996,0.007184624671936035,0.008763909339904785,0.008635878562927246,0.007524847984313965,0.006035923957824707,0.004903078079223633,0.003116846084594727,0.0005962848663330078,-0.0009620189666748047,-0.001315832138061523,-0.0005584955215454102,-6.341934204101562e-05,0.0008754730224609375,0.001865029335021973,0.002503871917724609,0.003023266792297363,0.004005312919616699,0.004222989082336426,0.002845525741577148,0.001138210296630859,0.0002186298370361328,0.0002522468566894531,0.0004903078079223633,0.000798344612121582,0.0007605552673339844,0.0009381771087646484,0.00109410285949707,0.002028107643127441,0.002710580825805664,0.003205418586730957,0.002398133277893066,0.00140690803527832,0.001601338386535645,0.002780318260192871,0.003748893737792969,0.003319740295410156,0.001922965049743652,0.0008367300033569336,0.0004886388778686523,3.492832183837891e-05,-1.156330108642578e-05,0.0003888607025146484,0.0009398460388183594,0.001845955848693848,0.003032207489013672,0.004349589347839355,0.00478053092956543,0.004723072052001953,0.004287600517272949,0.003477215766906738,0.002956628799438477,0.002943992614746094,0.002897739410400391,0.002524256706237793,0.001054644584655762,-4.935264587402344e-05,6.67572021484375e-06,0.00227653980255127,0.004897475242614746,0.006825685501098633,0.007072210311889648,0.006538152694702148,0.005728006362915039,0.00549161434173584,0.004336833953857422,0.00215458869934082,6.186962127685547e-05,-0.002012968063354492,-0.003972053527832031,-0.005088686943054199,-0.005018711090087891,-0.00387883186340332,-0.002890944480895996,-0.002166390419006348,-0.001090645790100098,0.001536726951599121,0.004920601844787598,0.007732152938842773,0.009550571441650391,0.009885549545288086,0.008841991424560547,0.007448911666870117,0.006315350532531738,0.005100846290588379,0.003764867782592773,0.00290524959564209,0.002028703689575195,0.0006281137466430664,-0.0006673336029052734,-0.001712322235107422,-0.002939820289611816,-0.003581881523132324,-0.004145622253417969,-0.004192590713500977,-0.003760933876037598,-0.003132820129394531,-0.002462029457092285,-0.001108884811401367,0.0007708072662353516,0.002843022346496582,0.004094600677490234,0.004178643226623535,0.004295229911804199,0.004699468612670898,0.00475621223449707,0.003723263740539551,0.00246429443359375,0.002059578895568848,0.001894950866699219,0.002239108085632324,0.003477692604064941,0.005039453506469727,0.005897760391235352,0.005512714385986328,0.004069924354553223,0.002615690231323242,0.002563714981079102,0.003323197364807129,0.003404855728149414,0.002637028694152832,0.001367926597595215,-0.0001608133316040039,-0.001065969467163086,-0.0001555681228637695,0.001137495040893555,0.001931428909301758,0.003053188323974609,0.004755139350891113,0.006249427795410156,0.006977081298828125,0.007302761077880859,0.007412314414978027,0.006850481033325195,0.005826354026794434,0.005113959312438965,0.004750370979309082,0.00471806526184082,0.004546284675598145,0.003565430641174316,0.002749443054199219,0.002825617790222168,0.003009796142578125,0.002871394157409668,0.002458691596984863,0.002410292625427246,0.003276586532592773,0.004278182983398438,0.004680991172790527,0.005234360694885254,0.006293892860412598,0.006640195846557617,0.006801128387451172,0.006579041481018066,0.00531315803527832,0.003514885902404785,0.002461433410644531,0.002428889274597168,0.0008025169372558594,-0.002715110778808594,-0.006465435028076172,-0.007977604866027832,-0.006902337074279785,-0.005023717880249023,-0.003407120704650879,-0.00148165225982666,0.0004763603210449219,0.002500176429748535,0.004999876022338867,0.006945610046386719,0.00698387622833252,0.005801916122436523,0.005350947380065918,0.006139039993286133,0.007681369781494141,0.009273767471313477,0.009994745254516602,0.01003611087799072,0.009613156318664551,0.009127616882324219,0.008592367172241211,0.007493734359741211,0.00683295726776123,0.004980206489562988,0.0009387731552124023,-0.004510641098022461,-0.008626222610473633,-0.01057624816894531,-0.01071548461914062,-0.009756565093994141,-0.008148908615112305,-0.005887389183044434,-0.003414630889892578,1.871585845947266e-05,0.003218770027160645,0.00565338134765625,0.00709831714630127,0.007271409034729004,0.007738351821899414,0.008789896965026855,0.0100865364074707,0.01113390922546387,0.0121837854385376,0.01294219493865967,0.01258385181427002,0.01117360591888428,0.009166955947875977,0.006674766540527344,0.003973245620727539,0.001854777336120605,0.0004073381423950195,-0.0006871223449707031,-0.001451015472412109,-0.002138614654541016,-0.001891493797302246,-0.0005577802658081055,0.001952409744262695,0.005109429359436035,0.007928013801574707,0.008948326110839844,0.007926464080810547,0.005957961082458496,0.004347443580627441,0.003661751747131348,0.003337860107421875,0.002951741218566895,0.002657175064086914,0.002475976943969727,0.002321481704711914,0.003168344497680664,0.004799485206604004,0.005708694458007812,0.005405068397521973,0.00446927547454834,0.004259586334228516,0.00502169132232666,0.006150960922241211,0.00652158260345459,0.005887150764465332,0.004936933517456055,0.004449605941772461,0.003509640693664551,0.002597570419311523,0.003221988677978516,0.004691123962402344,0.005691766738891602,0.004937648773193359,0.003109931945800781,0.002161264419555664,0.001338601112365723,0.0002260208129882812,-0.0002666711807250977,0.0002310276031494141,0.001196146011352539,0.002706408500671387,0.004833340644836426,0.006768703460693359,0.008874654769897461,0.01118791103363037,0.01370894908905029,0.01404893398284912,0.01150417327880859,0.00780785083770752,0.00471198558807373,0.002424955368041992,0.0003213882446289062,-0.001495361328125,-0.003998994827270508,-0.005708932876586914,-0.00589287281036377,-0.004565954208374023,-0.002333641052246094,-2.193450927734375e-05,0.001596808433532715,0.001912117004394531,0.001562952995300293,0.001905441284179688,0.002727866172790527,0.003519177436828613,0.003818750381469727,0.004389166831970215,0.005165576934814453,0.006174921989440918,0.006965875625610352,0.006797313690185547,0.006543874740600586,0.00607144832611084,0.00476682186126709,0.003369927406311035,0.002500534057617188,0.001053690910339355,-0.001809835433959961,-0.005112171173095703,-0.007079839706420898,-0.006406426429748535,-0.004749417304992676,-0.001975059509277344,0.0008711814880371094,0.002704143524169922,0.004975199699401855,0.008355855941772461,0.010886549949646,0.01154506206512451,0.01150393486022949,0.01015138626098633,0.007791042327880859,0.004941105842590332,0.002699017524719238,0.0006273984909057617,-0.0006154775619506836,-0.0006070137023925781,0.0002348423004150391,0.001334547996520996,0.002263069152832031,0.003181695938110352,0.003998875617980957,0.005270838737487793,0.00573122501373291,0.005546212196350098,0.005321741104125977,0.005447149276733398,0.005808234214782715,0.006383061408996582,0.006421566009521484,0.006151080131530762,0.005450725555419922,0.004872560501098633,0.004052877426147461,0.003111124038696289,0.001294970512390137,-0.0005438327789306641,-0.001842141151428223,-0.002367019653320312,-0.002092599868774414,-0.00206756591796875,-0.00241541862487793,-0.00297248363494873,-0.002245903015136719,0.0004122257232666016,0.004109025001525879,0.007346630096435547,0.00865781307220459,0.008683681488037109,0.009058356285095215,0.01028585433959961,0.0104750394821167,0.009043455123901367,0.005926609039306641,0.00242304801940918,-0.0006203651428222656,-0.002512097358703613,-0.002347350120544434,-0.001318693161010742,-0.0007688999176025391,-0.0003997087478637695,0.0004554986953735352,0.001351714134216309,0.002209067344665527,0.003453969955444336,0.004539728164672852,0.004765748977661133,0.004258632659912109,0.003098845481872559,0.002054929733276367,0.001512527465820312,0.002094864845275879,0.003824472427368164,0.006102681159973145,0.007373452186584473,0.008119583129882812,0.008759498596191406,0.008908510208129883,0.008987307548522949,0.00821387767791748,0.005788922309875488,0.003278255462646484,0.001739621162414551,0.001840710639953613,0.002540826797485352,0.002959609031677246,0.002661824226379395,0.001491069793701172,0.0002874135971069336,-0.0005005598068237305,-0.0002845525741577148,0.0008294582366943359,0.001952409744262695,0.002192378044128418,0.002256512641906738,0.002874135971069336,0.004072427749633789,0.005205512046813965,0.006327629089355469,0.007820963859558105,0.008957028388977051,0.009678483009338379,0.01106786727905273,0.01096498966217041,0.009283542633056641,0.006334304809570312,0.002711057662963867,-0.001680254936218262,-0.00409245491027832,-0.003754138946533203,-0.002360820770263672,-0.0009903907775878906,-4.100799560546875e-05,0.00220024585723877,0.006500959396362305,0.01241254806518555,0.01819491386413574,0.02031755447387695,0.01796770095825195,0.01308965682983398,0.008166074752807617,0.003933072090148926,-0.0004459619522094727,-0.005247116088867188,-0.01000392436981201,-0.01143813133239746,-0.009362578392028809,-0.005912065505981445,-0.002018332481384277,0.001699328422546387,0.005302071571350098,0.008095264434814453,0.009414434432983398,0.01008915901184082,0.00928044319152832,0.007778763771057129,0.005493044853210449,0.003080010414123535,0.001293182373046875,0.0008995532989501953,0.001190423965454102,0.0007700920104980469,0.001081943511962891,0.003464698791503906,0.00715935230255127,0.01024830341339111,0.01149082183837891,0.01024842262268066,0.008799552917480469,0.008810520172119141,0.009149789810180664,0.00763249397277832,0.004752159118652344,0.002516627311706543,0.001481294631958008,0.0009779930114746094,-0.0004807710647583008,-0.002559781074523926,-0.003883481025695801,-0.003172039985656738,-0.001040220260620117,0.0003132820129394531,-0.0001169443130493164,-0.001404643058776855,-0.001341342926025391,0.0003222227096557617,0.001955389976501465,0.002994179725646973,0.003252148628234863,0.003520011901855469,0.004743695259094238,0.006035208702087402,0.006189107894897461,0.005899190902709961,0.005801081657409668,0.005850315093994141,0.006048083305358887,0.006224870681762695,0.006544113159179688,0.006189346313476562,0.00532078742980957,0.004375100135803223,0.004585981369018555,0.005225300788879395,0.005370259284973145,0.0045166015625,0.003290295600891113,0.001780152320861816,0.0003267526626586914,-0.001442551612854004,-0.003554344177246094,-0.005612730979919434,-0.006202101707458496,-0.004965901374816895,-0.002784967422485352,-0.0003952980041503906,0.0005486011505126953,0.000683903694152832,0.002946138381958008,0.006267428398132324,0.008606910705566406,0.009251236915588379,0.008617520332336426,0.008069276809692383,0.007369160652160645,0.005463838577270508,0.002924919128417969,0.001513361930847168,0.0003707408905029297,-0.001213908195495605,-0.002507925033569336,-0.003513097763061523,-0.003804802894592285,-0.003664374351501465,-0.003270268440246582,-0.003084301948547363,-0.001938462257385254,-0.001020073890686035,-0.001093864440917969,-0.001427054405212402,-0.0004875659942626953,0.00119173526763916,0.003673911094665527,0.004865884780883789,0.00449216365814209,0.003924369812011719,0.004186630249023438,0.004072189331054688,0.004457712173461914,0.005889058113098145,0.007074117660522461,0.006899476051330566,0.004949808120727539,0.0015869140625,-0.001432895660400391,-0.003625869750976562,-0.005145907402038574,-0.005563735961914062,-0.004862070083618164,-0.003430366516113281,-0.0007004737854003906,0.001113295555114746,0.001998186111450195,0.003175497055053711,0.004560947418212891,0.00523686408996582,0.004513263702392578,0.002062201499938965,-0.0007658004760742188,-0.004561901092529297,-0.007456064224243164,-0.007634997367858887,-0.005991458892822266,-0.003792285919189453,-0.001544594764709473,0.0004568099975585938,0.002365589141845703,0.003731369972229004,0.005516648292541504,0.008027911186218262,0.01010608673095703,0.009883284568786621,0.006788969039916992,0.003218293190002441,0.001359224319458008,0.001426815986633301,0.003149986267089844,0.004058599472045898,0.003914833068847656,0.003098607063293457,0.00370633602142334,0.005106806755065918,0.006028056144714355,0.006375908851623535,0.00571131706237793,0.00420844554901123,0.002062797546386719,0.0003149509429931641,-0.001681089401245117,-0.003588199615478516,-0.005697250366210938,-0.007892251014709473,-0.008728265762329102,-0.006898403167724609,-0.003203868865966797,0.001685142517089844,0.00712132453918457,0.01107180118560791,0.01297307014465332,0.01274967193603516,0.01212048530578613,0.01025009155273438,0.008723258972167969,0.00760495662689209,0.005625724792480469,0.001984238624572754,-0.001991391181945801,-0.003867506980895996,-0.002216100692749023,0.0004479885101318359,0.001955866813659668,0.001683592796325684,0.001942038536071777,0.003700375556945801,0.005491971969604492,0.005428433418273926,0.002740740776062012,-0.0001277923583984375,-0.00120389461517334,-0.001510739326477051,-0.001251816749572754,-0.001354455947875977,-0.001549601554870605,-0.001477479934692383,-0.0006710290908813477,0.0005196332931518555,0.001073598861694336,0.001140236854553223,0.001344561576843262,0.001418113708496094,0.001668453216552734,0.00229942798614502,0.002473950386047363,0.002460241317749023,0.002270817756652832,0.001209020614624023,0.0006371736526489258,0.001792192459106445,0.003226757049560547,0.004012942314147949,0.005022764205932617,0.006249308586120605,0.007469058036804199,0.007962703704833984,0.006998658180236816,0.004520058631896973,0.002848505973815918,0.002892136573791504,0.002537012100219727,0.002551674842834473,0.003137469291687012,0.004110217094421387,0.005437374114990234,0.007190346717834473,0.007720112800598145,0.007377862930297852,0.006878256797790527,0.005875229835510254,0.003252625465393066,0.0004841089248657227,-0.002338409423828125,-0.005532145500183105,-0.008078098297119141,-0.007513284683227539,-0.004636287689208984,-0.001496672630310059,-0.0001529455184936523,-0.001655697822570801,-0.002450346946716309,-0.0006628036499023438,0.002008676528930664,0.003597617149353027,0.003925085067749023,0.003442525863647461,0.004046082496643066,0.005656599998474121,0.007163047790527344,0.008667111396789551,0.008793234825134277,0.007167816162109375,0.005056142807006836,0.003967881202697754,0.003902196884155273,0.00372469425201416,0.002162933349609375,-0.00140845775604248,-0.004839181900024414,-0.004694700241088867,-0.001263976097106934,0.002136945724487305,0.003654003143310547,0.004278421401977539,0.004791498184204102,0.006650924682617188,0.008904814720153809,0.01017367839813232,0.009199023246765137,0.006347775459289551,0.003735184669494629,0.002382755279541016,0.002448320388793945,0.002418279647827148,0.0007354021072387695,-0.001481056213378906,-0.002326011657714844,-0.001379847526550293,-0.0004487037658691406,-0.0005899667739868164,-0.001247286796569824,-0.000931859016418457,4.982948303222656e-05,0.001993417739868164,0.003407597541809082,0.00374138355255127,0.003293156623840332,0.003632068634033203,0.005631923675537109,0.008323550224304199,0.01143848896026611,0.0131983757019043,0.01184451580047607,0.008743524551391602,0.006429791450500488,0.005298376083374023,0.004745721817016602,0.003582119941711426,0.001152157783508301,-0.001998662948608398,-0.00381922721862793,-0.003455638885498047,-0.002915740013122559,-0.003620386123657227,-0.003506779670715332,-0.002240777015686035,-0.0007218122482299805,0.001548528671264648,0.004562139511108398,0.00707089900970459,0.008731961250305176,0.009515523910522461,0.01062154769897461,0.0118328332901001,0.01140320301055908,0.008586764335632324,0.005546450614929199,0.00345158576965332,0.001815676689147949,-0.0002419948577880859,-0.002072572708129883,-0.00384819507598877,-0.005077600479125977,-0.004616498947143555,-0.003539919853210449,-0.002390623092651367,-0.0008826255798339844,0.000741124153137207,0.0008748769760131836,0.0007803440093994141,0.00120997428894043,0.00123131275177002,0.0009050369262695312,0.001034140586853027,0.0005067586898803711,-0.0001643896102905273,0.0002955198287963867,0.001926064491271973,0.00290679931640625,0.001809120178222656,0.0002424716949462891,0.0001701116561889648,0.001463174819946289,0.001929283142089844,0.001210451126098633,0.00132298469543457,0.00195002555847168,0.002207517623901367,0.001980304718017578,0.001671314239501953,0.00153040885925293,0.001123309135437012,7.402896881103516e-05,0.0001066923141479492,0.0005881786346435547,0.0002524852752685547,-0.000256657600402832,0.0003677606582641602,0.0009850263595581055,0.002400040626525879,0.003525853157043457,0.003165483474731445,0.004029631614685059,0.006104588508605957,0.007323622703552246,0.007322549819946289,0.006219148635864258,0.003806829452514648,0.0005606412887573242,-0.002670407295227051,-0.005346536636352539,-0.005762934684753418,-0.004889011383056641,-0.004534482955932617,-0.004445672035217285,-0.001969337463378906,0.002177119255065918,0.005149364471435547,0.006309151649475098,0.006914258003234863,0.008236527442932129,0.009375929832458496,0.008754491806030273,0.005630373954772949,0.00206303596496582,-0.0004324913024902344,-0.002296924591064453,-0.003918051719665527,-0.005207538604736328,-0.005243778228759766,-0.004031538963317871,-0.002673745155334473,-0.001384377479553223,0.0006157159805297852,0.002977371215820312,0.004683971405029297,0.00543975830078125,0.004873394966125488,0.004357337951660156,0.00455021858215332,0.004320383071899414,0.002983808517456055,0.001310467720031738,0.0005857944488525391,7.665157318115234e-05,-0.00173032283782959,-0.003711581230163574,-0.005805253982543945,-0.008625984191894531,-0.01072800159454346,-0.01059949398040771,-0.008614540100097656,-0.006492853164672852,-0.004996776580810547,-0.003688335418701172,-0.003023266792297363,-0.002033114433288574,-0.000285029411315918,0.001576542854309082,0.002868294715881348,0.003869533538818359,0.004218220710754395,0.004483222961425781,0.005809903144836426,0.007417559623718262,0.008100748062133789,0.007715940475463867,0.00637054443359375,0.004551529884338379,0.002762794494628906,0.00182807445526123,0.001866698265075684,0.001644253730773926,0.001168012619018555,0.0003118515014648438,8.7738037109375e-05,0.0009392499923706055,0.003250718116760254,0.004508852958679199,0.003703713417053223,0.0009596347808837891,-0.001553893089294434,-0.003722667694091797,-0.005468606948852539,-0.006274580955505371,-0.0061492919921875,-0.005272150039672852,-0.00328826904296875,-0.0007804632186889648,0.002730131149291992,0.006854414939880371,0.01001608371734619,0.01041865348815918,0.00912630558013916,0.007963061332702637,0.006891131401062012,0.004931330680847168,0.002566337585449219,-0.0001585483551025391,-0.002630114555358887,-0.00442194938659668,-0.004597187042236328,-0.003679633140563965,-0.003607392311096191,-0.003376603126525879,-0.001978397369384766,-0.0002715587615966797,0.0009605884552001953,0.00158536434173584,0.0007195472717285156,-0.00142824649810791,-0.002848029136657715,-0.003385782241821289,-0.004268169403076172,-0.00509190559387207,-0.005831599235534668,-0.006875753402709961,-0.006028890609741211,-0.002582430839538574,0.001571297645568848,0.004290580749511719,0.00792384147644043,0.01186108589172363,0.012603759765625,0.01073980331420898,0.008658170700073242,0.00721275806427002,0.006023764610290527,0.004640579223632812,0.003474235534667969,0.003644227981567383,0.004674911499023438,0.00503075122833252,0.004341363906860352,0.00298607349395752,0.002327680587768555,0.002826213836669922,0.003629207611083984,0.004022836685180664,0.00331878662109375,0.00243842601776123,0.001905202865600586,0.001408576965332031,0.0004736185073852539,-0.000872492790222168,-0.00255894660949707,-0.003302574157714844,-0.002771735191345215,-0.0007654428482055664,0.001955032348632812,0.002402186393737793,0.001056194305419922,0.001380562782287598,0.003170132637023926,0.006190896034240723,0.009738564491271973,0.009787678718566895,0.005688786506652832,0.001662969589233398,5.125999450683594e-05,-0.0009251832962036133,-0.001470565795898438,-0.002483248710632324,-0.004855155944824219,-0.005639553070068359,-0.003528714179992676,-0.0003106594085693359,0.003448724746704102,0.007409214973449707,0.01055729389190674,0.01275932788848877,0.01336216926574707,0.01105666160583496,0.005708098411560059,-0.0007473230361938477,-0.005432248115539551,-0.007310628890991211,-0.006654739379882812,-0.005554556846618652,-0.005795955657958984,-0.00686347484588623,-0.006335735321044922,-0.004257559776306152,-0.0008637905120849609,0.002959012985229492,0.005815029144287109,0.007135152816772461,0.006865262985229492,0.006502747535705566,0.005744814872741699,0.004360795021057129,0.002203583717346191,0.001089572906494141,0.0008392333984375,-0.001202583312988281,-0.004573941230773926,-0.006879210472106934,-0.006889700889587402,-0.004851818084716797,-0.002378225326538086,-5.459785461425781e-05,0.001885175704956055,0.004529237747192383,0.007892012596130371,0.009060382843017578,0.008995532989501953,0.00852656364440918,0.007477521896362305,0.006236076354980469,0.003860831260681152,9.548664093017578e-05,-0.003006815910339355,-0.005631804466247559,-0.006629586219787598,-0.005307674407958984,-0.00452876091003418,-0.00564110279083252,-0.00677955150604248,-0.005211949348449707,-0.002643227577209473,-0.00108790397644043,-0.0002217292785644531,0.0002840757369995117,0.0003165006637573242,0.0001589059829711914,0.0002189874649047852,0.0001541376113891602,0.0006363391876220703,0.001408815383911133,0.00178074836730957,0.001631736755371094,0.001828908920288086,0.002676248550415039,0.004245400428771973,0.005658268928527832,0.00602269172668457,0.003473162651062012,-0.0008578300476074219,-0.003831386566162109,-0.004789471626281738,-0.005097270011901855,-0.005324482917785645,-0.005262851715087891,-0.004923820495605469,-0.00251460075378418,0.00296485424041748,0.00879979133605957,0.01203227043151855,0.0128096342086792,0.0132904052734375,0.01310110092163086,0.01130270957946777,0.008144140243530273,0.004507303237915039,0.001373291015625,-0.001252174377441406,-0.003188848495483398,-0.004428267478942871,-0.004119396209716797,-0.001441001892089844,0.00208592414855957,0.00492393970489502,0.005697131156921387,0.004833579063415527,0.004041433334350586,0.003546595573425293,0.003416657447814941,0.001784205436706543,-0.0006480216979980469,-0.001683712005615234,-0.0006709098815917969,0.0008797645568847656,3.898143768310547e-05,-0.003406047821044922,-0.006567478179931641,-0.006106376647949219,-0.002358436584472656,0.000771641731262207,0.0005587339401245117,-0.0005037784576416016,0.0005202293395996094,0.003823637962341309,0.00729525089263916,0.008555054664611816,0.007698178291320801,0.005461692810058594,0.00340425968170166,0.001766443252563477,0.001050353050231934,0.001424551010131836,0.001829743385314941,0.0009788274765014648,-0.002046704292297363,-0.004749536514282227,-0.006146669387817383,-0.004889249801635742,-0.002448201179504395,-0.002045273780822754,-0.003840327262878418,-0.005033612251281738,-0.004005074501037598,-0.001717925071716309,0.001063346862792969,0.002270698547363281,0.001638889312744141,0.0008388757705688477,0.001030206680297852,0.00243079662322998,0.003363251686096191,0.00278019905090332,0.0009744167327880859,0.0006988048553466797,0.002547621726989746,0.004718661308288574,0.004981279373168945,0.003238558769226074,0.001091837882995605,0.0006299018859863281,0.001300692558288574,7.343292236328125e-05,-0.003336906433105469,-0.006951808929443359,-0.008756041526794434,-0.008139133453369141,-0.006220698356628418,-0.005158662796020508,-0.005730509757995605,-0.005893468856811523,-0.004574060440063477,-0.001859426498413086,0.0005605220794677734,0.002003073692321777,0.003127455711364746,0.004446625709533691,0.005107760429382324,0.004360079765319824,0.003571629524230957,0.002637743949890137,0.001703381538391113,0.001639723777770996,0.001794695854187012,0.001144647598266602,0.0009686946868896484,0.001930356025695801,0.00313115119934082,0.004204869270324707,0.004408001899719238,0.004401087760925293,0.004436731338500977,0.003963112831115723,0.002027511596679688,-0.000690460205078125,-0.003073692321777344,-0.003673076629638672,-0.002729296684265137,-0.001923799514770508,-0.001455783843994141,-0.0009562969207763672,0.0002276897430419922,0.0008034706115722656,0.0009469985961914062,0.0009149312973022461,0.0003502368927001953,0.000147700309753418,2.384185791015625e-06,-0.00168454647064209,-0.003440141677856445,-0.003510117530822754,-0.001218795776367188,0.001519918441772461,0.002797245979309082,0.002939462661743164,0.003153324127197266,0.002335429191589355,6.341934204101562e-05,-0.004171133041381836,-0.008424162864685059,-0.0104135274887085,-0.009866595268249512,-0.009740471839904785,-0.01020145416259766,-0.008626937866210938,-0.003807187080383301,0.001863241195678711,0.006292819976806641,0.008539438247680664,0.007494926452636719,0.005213141441345215,0.004598140716552734,0.005817413330078125,0.006494998931884766,0.004693984985351562,0.001510858535766602,-0.0001555681228637695,0.0008325576782226562,0.001526474952697754,0.0006891489028930664,-0.0003137588500976562,-0.0003777742385864258,-0.0003026723861694336,-0.001404404640197754,-0.003795385360717773,-0.005584120750427246,-0.007736444473266602,-0.01067483425140381,-0.01152586936950684,-0.009423732757568359,-0.006125569343566895,-0.002669095993041992,-0.0005754232406616211,-0.0001457929611206055,0.0007975101470947266,0.004074573516845703,0.008919715881347656,0.01218140125274658,0.01131999492645264,0.005946874618530273,0.0006690025329589844,-0.001644372940063477,-0.002879619598388672,-0.004880309104919434,-0.006976008415222168,-0.007747769355773926,-0.007265806198120117,-0.006592273712158203,-0.005485177040100098,-0.003330469131469727,-0.000348210334777832,0.002730607986450195,0.005236029624938965,0.008621931076049805,0.01214432716369629,0.01428663730621338,0.01442086696624756,0.01429712772369385,0.01519262790679932,0.01451075077056885,0.01169466972351074,0.009640336036682129,0.008137345314025879,0.004030466079711914,-0.002999782562255859,-0.00888979434967041,-0.01181244850158691,-0.01336503028869629,-0.01457810401916504,-0.0154653787612915,-0.01548624038696289,-0.01334595680236816,-0.0094757080078125,-0.005685806274414062,-0.002477049827575684,-3.528594970703125e-05,0.001516819000244141,0.001770853996276855,0.001573920249938965,0.002260684967041016,0.003420829772949219,0.00424039363861084,0.005412101745605469,0.00689089298248291,0.007202625274658203,0.007660388946533203,0.008601665496826172,0.01010978221893311,0.01251053810119629,0.014129638671875,0.01405251026153564,0.01311218738555908,0.0113213062286377,0.008371472358703613,0.00523829460144043,0.002585768699645996,-0.00122368335723877,-0.005920171737670898,-0.01054692268371582,-0.0133366584777832,-0.01435673236846924,-0.01305651664733887,-0.009635329246520996,-0.005216121673583984,-0.001258254051208496,0.002856850624084473,0.006718635559082031,0.009451866149902344,0.01050996780395508,0.009011030197143555,0.00554811954498291,0.001247286796569824,-0.002331852912902832,-0.005442142486572266,-0.006738662719726562,-0.005549073219299316,-0.003043055534362793,-3.635883331298828e-05,0.002996444702148438,0.004981398582458496,0.004351973533630371,0.002623677253723145,0.0006880760192871094,-0.001488685607910156,-0.003012657165527344,-0.004752397537231445,-0.007349014282226562,-0.009532451629638672,-0.01043057441711426,-0.01007735729217529,-0.007177114486694336,-0.002890467643737793,-0.0002418756484985352,0.001411557197570801,0.003255248069763184,0.004791140556335449,0.005852460861206055,0.005802154541015625,0.005367398262023926,0.004997372627258301,0.004480838775634766,0.004565238952636719,0.006217479705810547,0.007175445556640625,0.00405275821685791,-0.001471400260925293,-0.005045175552368164,-0.00666511058807373,-0.007737398147583008,-0.008909106254577637,-0.01008844375610352,-0.009976506233215332,-0.00768435001373291,-0.005470633506774902,-0.003475546836853027,-0.0002884864807128906,0.003509998321533203,0.00609278678894043,0.006037235260009766,0.003691673278808594,-0.0001101493835449219,-0.003514885902404785,-0.004926681518554688,-0.004960775375366211,-0.005147457122802734,-0.004542112350463867,-0.002768158912658691,-0.0001283884048461914,0.003820061683654785,0.00842738151550293,0.01193010807037354,0.01380228996276855,0.01336395740509033,0.01046991348266602,0.00734865665435791,0.004907608032226562,0.001952052116394043,-0.001893281936645508,-0.00592350959777832,-0.008660435676574707,-0.008328557014465332,-0.005577802658081055,-0.003108024597167969,-0.002338767051696777,-0.002367854118347168,-0.002454757690429688,-0.003175735473632812,-0.003912925720214844,-0.004300475120544434,-0.004210352897644043,-0.003452062606811523,-0.001311302185058594,0.001822352409362793,0.004631996154785156,0.006887555122375488,0.01019227504730225,0.01382994651794434,0.01411306858062744,0.01099419593811035,0.005955815315246582,0.0004739761352539062,-0.003362417221069336,-0.005528092384338379,-0.006239414215087891,-0.004947543144226074,-0.00274360179901123,-0.0004827976226806641,0.001455426216125488,0.001997709274291992,0.001067757606506348,0.0005134344100952148,0.0006046295166015625,0.001724720001220703,0.001704812049865723,-0.002011299133300781,-0.008191585540771484,-0.01265072822570801,-0.01111531257629395,-0.005376219749450684,0.0006290674209594727,0.005434155464172363,0.008516073226928711,0.01090824604034424,0.01376855373382568,0.0145728588104248,0.01292586326599121,0.01027214527130127,0.006295680999755859,0.002017736434936523,-0.001947283744812012,-0.005885481834411621,-0.008821845054626465,-0.01041078567504883,-0.01077282428741455,-0.009414911270141602,-0.00648045539855957,-0.003596663475036621,-0.001721739768981934,-0.0007187128067016602,-0.0008766651153564453,-0.001615285873413086,-0.002478241920471191,-0.003273844718933105,-0.00430750846862793,-0.005740165710449219,-0.007062911987304688,-0.007488727569580078,-0.005040526390075684,-0.0006253719329833984,0.003423452377319336,0.006107091903686523,0.006797432899475098,0.005727410316467285,0.004900932312011719,0.003990411758422852,0.001729726791381836,-0.00156855583190918,-0.004102706909179688,-0.005236506462097168,-0.004933714866638184,-0.003471732139587402,-0.001696348190307617,0.002561688423156738,0.00680994987487793,0.007748126983642578,0.006846904754638672,0.005773067474365234,0.003265261650085449,-0.0005415678024291992,-0.003419399261474609,-0.005302667617797852,-0.005973935127258301,-0.005145788192749023,-0.002907037734985352,-0.0001358985900878906,0.002920389175415039,0.004800081253051758,0.004433989524841309,0.003872394561767578,0.004588007926940918,0.005059599876403809,0.003048419952392578,-0.001948952674865723,-0.007579684257507324,-0.0118941068649292,-0.01245880126953125,-0.01046955585479736,-0.009263038635253906,-0.009907126426696777,-0.009735941886901855,-0.00744938850402832,-0.00365746021270752,0.0006920099258422852,0.004665374755859375,0.006742715835571289,0.00801384449005127,0.007780313491821289,0.005277037620544434,0.002759337425231934,0.00298774242401123,0.004470705986022949,0.005414247512817383,0.004010796546936035,0.0007321834564208984,-0.001482605934143066,-0.003152251243591309,-0.005315303802490234,-0.00652921199798584,-0.006238460540771484,-0.006652951240539551,-0.008136391639709473,-0.008676052093505859,-0.008953690528869629,-0.009318709373474121,-0.009719133377075195,-0.00868690013885498,-0.006876468658447266,-0.00424802303314209,-0.00175940990447998,-0.0001609325408935547,0.002013683319091797,0.004306554794311523,0.006081700325012207,0.006513595581054688,0.006228327751159668,0.005022525787353516,0.003989577293395996,0.002524137496948242,0.0002684593200683594,-0.002660751342773438,-0.005826115608215332,-0.008706569671630859,-0.01018905639648438,-0.01170575618743896,-0.01331150531768799,-0.01366078853607178,-0.01254653930664062,-0.01028573513031006,-0.007205486297607422,-0.004483699798583984,-0.003699421882629395,-0.002582907676696777,0.0008949041366577148,0.003813982009887695,0.005305767059326172,0.005822420120239258,0.004774570465087891,0.001902937889099121,-0.0001940727233886719,-0.0003354549407958984,-0.0008897781372070312,-0.002887606620788574,-0.004404187202453613,-0.005463838577270508,-0.00593256950378418,-0.004828810691833496,-0.001386165618896484,0.002331256866455078,0.005431175231933594,0.006346583366394043,0.005966424942016602,0.006086826324462891,0.005659818649291992,0.00574958324432373,0.008420586585998535,0.009757280349731445,0.005378365516662598,-0.0007648468017578125,-0.005652904510498047,-0.008540749549865723,-0.007810235023498535,-0.006126046180725098,-0.006228208541870117,-0.008380889892578125,-0.01049149036407471,-0.01123154163360596,-0.008780241012573242,-0.005584597587585449,-0.003595471382141113,-0.003735542297363281,-0.005269408226013184,-0.005239486694335938,-0.002185344696044922,0.00196993350982666,0.004848122596740723,0.004248499870300293,0.0009301900863647461,-0.002268195152282715,-0.003936290740966797,-0.003938913345336914,-0.002400994300842285,-0.001122474670410156,-4.875659942626953e-05,0.002831101417541504,0.007373690605163574,0.009445905685424805,0.008633852005004883,0.007169127464294434,0.005478143692016602,0.003928542137145996,0.002644062042236328,0.0008925199508666992,-0.00159001350402832,-0.005751371383666992,-0.008238315582275391,-0.006789803504943848,-0.003997325897216797,-0.003564238548278809,-0.005233526229858398,-0.007062554359436035,-0.007585883140563965,-0.006348490715026855,-0.005757331848144531,-0.0075225830078125,-0.01061201095581055,-0.01301753520965576,-0.01438164710998535,-0.01376438140869141,-0.01197385787963867,-0.01067590713500977,-0.01057422161102295,-0.01180636882781982,-0.01322686672210693,-0.01098597049713135,-0.00691676139831543,-0.004023551940917969,-0.002485275268554688,-0.001776337623596191,-0.0007582902908325195,0.003328680992126465,0.008234739303588867,0.01006245613098145,0.007820963859558105,0.004036545753479004,0.001777291297912598,0.00129246711730957,0.001391053199768066,0.002238035202026367,0.002428174018859863,0.001198530197143555,0.0001299381256103516,-0.0005692243576049805,-0.001130461692810059,-0.0008565187454223633,-0.001702070236206055,-0.006458759307861328,-0.01253831386566162,-0.01493191719055176,-0.01323091983795166,-0.01204288005828857,-0.01193249225616455,-0.01081645488739014,-0.009698033332824707,-0.009460806846618652,-0.00908815860748291,-0.008878827095031738,-0.008862853050231934,-0.008427977561950684,-0.007947206497192383,-0.008511900901794434,-0.009096503257751465,-0.0076751708984375,-0.006196856498718262,-0.004908204078674316,-0.0008782148361206055,0.004244089126586914,0.006704330444335938,0.007385969161987305,0.006393790245056152,0.004256367683410645,0.002617120742797852,0.001456856727600098,-7.390975952148438e-06,-0.003203153610229492,-0.005690217018127441,-0.007474064826965332,-0.009217739105224609,-0.009635329246520996,-0.008012890815734863,-0.006659984588623047,-0.004549026489257812,-0.001734733581542969,0.00141453742980957,0.005942106246948242,0.01209914684295654,0.01460707187652588,0.01240158081054688,0.008383989334106445,0.003525257110595703,-0.000906825065612793,-0.00358736515045166,-0.005298733711242676,-0.006028056144714355,-0.005875349044799805,-0.005828380584716797,-0.005985140800476074,-0.004281401634216309,-0.001673579216003418,-0.0008161067962646484,-0.001264095306396484,-0.0007332563400268555,0.001294493675231934,0.00315701961517334,0.003840446472167969,0.001280307769775391,-0.003833770751953125,-0.007757663726806641,-0.007591843605041504,-0.004465699195861816,-0.001980423927307129,-0.0002062320709228516,0.00133061408996582,0.002222299575805664,0.001944899559020996,0.0001993179321289062,-5.280971527099609e-05,0.001659870147705078,0.003021359443664551,0.001806378364562988,-0.002404332160949707,-0.008352160453796387,-0.01251161098480225,-0.01329636573791504,-0.01256263256072998,-0.01127016544342041,-0.009773015975952148,-0.008886814117431641,-0.007664680480957031,-0.004729270935058594,-0.001160264015197754,0.001054048538208008,0.0003856420516967773,-0.0003987550735473633,0.0003571510314941406,0.002600669860839844,0.004221916198730469,0.005077242851257324,0.00522911548614502,0.004958868026733398,0.004488229751586914,0.004049062728881836,0.002445578575134277,0.0003578662872314453,-0.0007219314575195312,-0.001011967658996582,-0.001059770584106445,-0.001217126846313477,-0.003217935562133789,-0.005231261253356934,-0.005495905876159668,-0.003965973854064941,-0.000494837760925293,0.002926826477050781,0.003756046295166016,0.001392245292663574,-0.0008919239044189453,-0.0004992485046386719,0.001628994941711426,0.0005058050155639648,-0.003108382225036621,-0.006761789321899414,-0.008991718292236328,-0.008045792579650879,-0.005622982978820801,-0.004945874214172363,-0.006041765213012695,-0.005585432052612305,-0.003479361534118652,-0.0006405115127563477,0.004158854484558105,0.008731722831726074,0.009576797485351562,0.007773518562316895,0.005960464477539062,0.005174994468688965,0.003100275993347168,-0.001365900039672852,-0.007777810096740723,-0.01358568668365479,-0.01649069786071777,-0.01619255542755127,-0.01419532299041748,-0.01249301433563232,-0.01039862632751465,-0.007573843002319336,-0.00465857982635498,-0.00247657299041748,-0.001228928565979004,0.001092672348022461,0.00333714485168457,0.004110813140869141,0.003602743148803711,0.002827048301696777,0.003879547119140625,0.004533290863037109,0.002650976181030273,0.001169443130493164,-0.001583695411682129,-0.005388498306274414,-0.006960511207580566,-0.008664250373840332,-0.01143002510070801,-0.01314759254455566,-0.01218461990356445,-0.008707165718078613,-0.005632519721984863,-0.005623102188110352,-0.006490349769592285,-0.005367517471313477,-0.002833962440490723,-0.0007066726684570312,0.001401901245117188,0.003406405448913574,0.006051540374755859,0.009410262107849121,0.01161348819732666,0.0104595422744751,0.00663912296295166,0.001046299934387207,-0.004722952842712402,-0.008545398712158203,-0.01082181930541992,-0.0123370885848999,-0.01337409019470215,-0.01332306861877441,-0.0115816593170166,-0.006256341934204102,0.0006238222122192383,0.005702972412109375,0.01050269603729248,0.01319670677185059,0.01242482662200928,0.009415626525878906,0.004306554794311523,-0.001741409301757812,-0.007667660713195801,-0.01450908184051514,-0.01997089385986328,-0.02193522453308105,-0.02141118049621582,-0.02030491828918457,-0.01759433746337891,-0.01220321655273438,-0.005833029747009277,-0.0009503364562988281,0.002785682678222656,0.006325364112854004,0.008102178573608398,0.007696986198425293,0.004972338676452637,0.001389861106872559,-0.002066969871520996,-0.005447983741760254,-0.007522225379943848,-0.008935451507568359,-0.008703827857971191,-0.007148981094360352,-0.005497217178344727,-0.005478143692016602,-0.005781888961791992,-0.004911661148071289,-0.002634286880493164,0.0008453130722045898,0.004197001457214355,0.004770040512084961,0.002426743507385254,-0.000357508659362793,-0.001987695693969727,-0.0009434223175048828,0.0003170967102050781,-0.001635074615478516,-0.005844235420227051,-0.008492231369018555,-0.009275674819946289,-0.009242773056030273,-0.009068965911865234,-0.008443593978881836,-0.006595611572265625,-0.002471208572387695,0.002199769020080566,0.006033658981323242,0.009273171424865723,0.0104835033416748,0.009991288185119629,0.007486581802368164,0.001656293869018555,-0.006301999092102051,-0.01279032230377197,-0.01685535907745361,-0.01816940307617188,-0.01769578456878662,-0.01524662971496582,-0.01016223430633545,-0.002910375595092773,0.003333568572998047,0.005289196968078613,0.005797266960144043,0.008333444595336914,0.01032543182373047,0.008809089660644531,0.003744006156921387,-0.001862049102783203,-0.005561470985412598,-0.006832242012023926,-0.005347132682800293,-0.00159919261932373,0.001561403274536133,0.003044486045837402,0.004245519638061523,0.005158782005310059,0.004892587661743164,0.001564741134643555,-0.003251314163208008,-0.005924820899963379,-0.00517582893371582,-0.003810405731201172,-0.002483010292053223,0.0003678798675537109,0.003922343254089355,0.007616281509399414,0.01006233692169189,0.009143352508544922,0.006660103797912598,0.004181265830993652,-0.0001932382583618164,-0.005444049835205078,-0.0107424259185791,-0.01534414291381836,-0.01838886737823486,-0.01812684535980225,-0.01530396938323975,-0.01122498512268066,-0.00520026683807373,0.002083659172058105,0.007714033126831055,0.009927153587341309,0.01028943061828613,0.01087355613708496,0.01043987274169922,0.006819248199462891,-0.0004056692123413086,-0.007468223571777344,-0.0113525390625,-0.01260590553283691,-0.01111245155334473,-0.005761384963989258,0.0006852149963378906,0.005583882331848145,0.01070261001586914,0.01493871212005615,0.01516389846801758,0.01499950885772705,0.01362109184265137,0.009064912796020508,0.002787351608276367,-0.003682613372802734,-0.009409070014953613,-0.01299738883972168,-0.01378834247589111,-0.01214301586151123,-0.01009678840637207,-0.007027149200439453,-0.002793550491333008,-0.0001863241195678711,0.0002764463424682617,-0.0002813339233398438,-0.001478791236877441,-0.001563191413879395,-0.001936674118041992,-0.003564119338989258,-0.00461268424987793,-0.003379940986633301,-0.001122355461120605,0.0006672143936157227,0.002408623695373535,0.005274057388305664,0.009145617485046387,0.01227307319641113,0.01296043395996094,0.01111817359924316,0.00878441333770752,0.00739288330078125,0.0072784423828125,0.006893277168273926,0.005036830902099609,0.003373861312866211,0.001697778701782227,-0.0005599260330200195,-0.002373456954956055,-0.002681732177734375,-0.002925753593444824,-0.004402399063110352,-0.006806492805480957,-0.01055681705474854,-0.0136946439743042,-0.01437759399414062,-0.01223659515380859,-0.009867668151855469,-0.00859987735748291,-0.007182002067565918,-0.004607915878295898,-0.003206253051757812,-0.003232955932617188,-0.00190579891204834,0.0002335309982299805,0.001330137252807617,0.001897692680358887,0.002861380577087402,0.00217902660369873,-0.0009534358978271484,-0.004342913627624512,-0.006693124771118164,-0.009030342102050781,-0.01133036613464355,-0.01276719570159912,-0.01336073875427246,-0.01208388805389404,-0.01028645038604736,-0.008589863777160645,-0.005263328552246094,-0.001941204071044922,-4.613399505615234e-05,0.002245545387268066,0.006675124168395996,0.0112311840057373,0.01518559455871582,0.01607811450958252,0.01209747791290283,0.007922172546386719,0.00718998908996582,0.006739377975463867,0.00353240966796875,-0.003350615501403809,-0.01185750961303711,-0.01888597011566162,-0.02202737331390381,-0.0213693380355835,-0.01757538318634033,-0.01301670074462891,-0.008630871772766113,-0.005029201507568359,-0.002220630645751953,0.0002284049987792969,0.00262141227722168,0.002785563468933105,0.0003429651260375977,-0.004171609878540039,-0.007079958915710449,-0.005559206008911133,-0.00223243236541748,2.312660217285156e-05,0.001464724540710449,0.004186153411865234,0.008055448532104492,0.01053929328918457,0.0104902982711792,0.008738040924072266,0.006009459495544434,0.004371285438537598,0.001424312591552734,-0.003910183906555176,-0.01003754138946533,-0.01511168479919434,-0.01742470264434814,-0.01540815830230713,-0.01004481315612793,-0.004205107688903809,-0.0001273155212402344,0.0007778406143188477,0.001447558403015137,0.002010345458984375,0.0007210969924926758,-0.002620458602905273,-0.008028745651245117,-0.01365935802459717,-0.01735162734985352,-0.01797211170196533,-0.01622843742370605,-0.01415860652923584,-0.0124661922454834,-0.01107370853424072,-0.00758814811706543,-0.001211404800415039,0.003465533256530762,0.003948330879211426,0.003256678581237793,0.002564787864685059,0.000750422477722168,-0.002158522605895996,-0.006211996078491211,-0.01026570796966553,-0.0129234790802002,-0.01420259475708008,-0.01279103755950928,-0.008090853691101074,-0.001162052154541016,0.005337238311767578,0.009795069694519043,0.01146626472473145,0.01068568229675293,0.007227778434753418,0.003922224044799805,0.00114285945892334,-0.001652836799621582,-0.003639936447143555,-0.005450725555419922,-0.007500648498535156,-0.009106636047363281,-0.01060390472412109,-0.01038229465484619,-0.005651473999023438,-0.0005460977554321289,0.000178217887878418,-0.002855420112609863,-0.005813121795654297,-0.006193161010742188,-0.004246830940246582,-0.001038074493408203,0.00055694580078125,0.001845598220825195,0.004465222358703613,0.006415843963623047,0.006073594093322754,0.005029916763305664,0.003789067268371582,0.002620339393615723,0.0001208782196044922,-0.0040283203125,-0.008930325508117676,-0.01248466968536377,-0.0126490592956543,-0.0114516019821167,-0.01105427742004395,-0.008529186248779297,-0.002758979797363281,0.001837491989135742,0.003252267837524414,0.002920866012573242,-0.00120079517364502,-0.008034110069274902,-0.01289308071136475,-0.01537907123565674,-0.01645195484161377,-0.01634347438812256,-0.01601314544677734,-0.01559329032897949,-0.01219594478607178,-0.006029248237609863,-6.687641143798828e-05,0.005429506301879883,0.008782625198364258,0.00929713249206543,0.007637143135070801,0.005089879035949707,0.002334475517272949,-0.002142667770385742,-0.006881833076477051,-0.008239507675170898,-0.007040619850158691,-0.004996418952941895,-0.004133820533752441,-0.003888487815856934,-0.001281619071960449,0.003318428993225098,0.008573293685913086,0.01502037048339844,0.01842939853668213,0.0163874626159668,0.01371479034423828,0.01283538341522217,0.009919166564941406,0.003794670104980469,-0.003421783447265625,-0.01021730899810791,-0.01568973064422607,-0.0193169116973877,-0.02097463607788086,-0.01927375793457031,-0.0151287317276001,-0.01209068298339844,-0.01095974445343018,-0.007422685623168945,-0.0003963708877563477,0.004170536994934082,0.004468679428100586,0.003708124160766602,0.003656983375549316,0.004608869552612305,0.005858778953552246,0.00704646110534668,0.009394168853759766,0.01203787326812744,0.01258480548858643,0.01094269752502441,0.006957530975341797,0.0004631280899047852,-0.005545139312744141,-0.01009559631347656,-0.01337838172912598,-0.01439905166625977,-0.01491057872772217,-0.01632297039031982,-0.01585972309112549,-0.01135778427124023,-0.00360417366027832,0.00321650505065918,0.007339239120483398,0.0109095573425293,0.01373660564422607,0.01286041736602783,0.007813811302185059,0.001797676086425781,-0.002687573432922363,-0.005348801612854004,-0.005840539932250977,-0.004315972328186035,-0.002837061882019043,-0.0009865760803222656,0.001944899559020996,0.004593968391418457,0.006744027137756348,0.005150079727172852,-0.001171231269836426,-0.008869290351867676,-0.0120997428894043,-0.01011133193969727,-0.006330132484436035,-0.004632949829101562,-0.006405115127563477,-0.008562684059143066,-0.004919171333312988,0.002624273300170898,0.008755326271057129,0.01110506057739258,0.008347034454345703,0.003553390502929688,0.0001282691955566406,-0.002180695533752441,-0.003067851066589355,-0.002388238906860352,-0.003248333930969238,-0.005738973617553711,-0.006513237953186035,-0.004391670227050781,0.0004752874374389648,0.005585908889770508,0.005891203880310059,0.001981496810913086,-0.0007408857345581055,-0.0009292364120483398,-0.002585649490356445,-0.006225824356079102,-0.01002311706542969,-0.01287937164306641,-0.01296114921569824,-0.009214878082275391,-0.005574464797973633,-0.005213499069213867,-0.003640055656433105,0.004011273384094238,0.01458775997161865,0.02243328094482422,0.02288353443145752,0.01667094230651855,0.0104745626449585,0.008332490921020508,0.007779836654663086,0.006495356559753418,0.003894209861755371,-0.000441431999206543,-0.005991816520690918,-0.008353948593139648,-0.006034493446350098,-0.002774715423583984,0.000408172607421875,0.003462076187133789,0.00307929515838623,0.0006898641586303711,-0.001217007637023926,-0.002772092819213867,-0.004227280616760254,-0.003296613693237305,-0.0007982254028320312,3.290176391601562e-05,0.002422451972961426,0.007271885871887207,0.01259815692901611,0.01581895351409912,0.01621270179748535,0.01505923271179199,0.01192176342010498,0.006281495094299316,0.0008383989334106445,-0.002042531967163086,-0.005412936210632324,-0.008880019187927246,-0.01073527336120605,-0.01204943656921387,-0.01325368881225586,-0.01114630699157715,-0.007109165191650391,-0.004711389541625977,-0.00570070743560791,-0.008941173553466797,-0.01394748687744141,-0.01761925220489502,-0.01648104190826416,-0.01213681697845459,-0.0102081298828125,-0.01184093952178955,-0.01252269744873047,-0.01120185852050781,-0.006855249404907227,-0.0003823041915893555,0.005566000938415527,0.008007645606994629,0.00749814510345459,0.007765531539916992,0.009386062622070312,0.01050543785095215,0.009617090225219727,0.005896568298339844,0.002023577690124512,-0.00308835506439209,-0.009868144989013672,-0.01254594326019287,-0.01050007343292236,-0.005433201789855957,0.002882599830627441,0.01120364665985107,0.01556813716888428,0.01760578155517578,0.01701700687408447,0.01295673847198486,0.006655573844909668,0.0003514289855957031,-0.00496208667755127,-0.01059699058532715,-0.01672232151031494,-0.02159333229064941,-0.02559471130371094,-0.02808284759521484,-0.02749991416931152,-0.02435123920440674,-0.01936912536621094,-0.01265799999237061,-0.006364941596984863,-0.002483487129211426,-0.0003684759140014648,0.001287221908569336,0.002841353416442871,0.004997611045837402,0.006377696990966797,0.004938125610351562,0.001206278800964355,-0.003554940223693848,-0.006242990493774414,-0.002509117126464844,0.002880454063415527,0.003294825553894043,-0.001066207885742188,-0.007120490074157715,-0.01167356967926025,-0.0140221118927002,-0.01591026782989502,-0.01746213436126709,-0.01677238941192627,-0.01283037662506104,-0.005855202674865723,0.001721858978271484,0.008398056030273438,0.01271378993988037,0.01532042026519775,0.01842904090881348,0.01699507236480713,0.01094412803649902,0.005005478858947754,0.0001777410507202148,-0.004719257354736328,-0.008138298988342285,-0.00874626636505127,-0.008059501647949219,-0.007438421249389648,-0.005750656127929688,-0.002685904502868652,0.0001164674758911133,0.0006669759750366211,-2.980232238769531e-06,-0.001161098480224609,-0.003399014472961426,-0.006210088729858398,-0.01128804683685303,-0.01942503452301025,-0.02453696727752686,-0.02416396141052246,-0.0179983377456665,-0.007294774055480957,0.002513766288757324,0.009934186935424805,0.01745986938476562,0.02374982833862305,0.02511465549468994,0.02300131320953369,0.01882708072662354,0.01133322715759277,0.001581788063049316,-0.008188486099243164,-0.01655972003936768,-0.02271485328674316,-0.02750611305236816,-0.03191149234771729,-0.03397774696350098,-0.03171753883361816,-0.02598011493682861,-0.0193030834197998,-0.01024341583251953,-0.0001356601715087891,0.007400035858154297,0.01218843460083008,0.01775705814361572,0.02428114414215088,0.02714836597442627,0.02439391613006592,0.01732325553894043,0.01012158393859863,0.007579445838928223,0.009149670600891113,0.007987737655639648,-0.0001373291015625,-0.0101923942565918,-0.01666378974914551,-0.01884210109710693,-0.01668798923492432,-0.01430702209472656,-0.01449167728424072,-0.01437640190124512,-0.01064908504486084,-0.006046772003173828,-0.002379655838012695,0.0002170801162719727,0.001185059547424316,0.0003591775894165039,-0.001880884170532227,-0.005577206611633301,-0.009664773941040039,-0.01270604133605957,-0.01363456249237061,-0.01189112663269043,-0.00519871711730957,0.00635981559753418,0.0167924165725708,0.02233433723449707,0.02612400054931641,0.02960371971130371,0.03062283992767334,0.02823555469512939,0.02090215682983398,0.01050889492034912,0.0004117488861083984,-0.008292436599731445,-0.01482880115509033,-0.01967859268188477,-0.02269601821899414,-0.02374541759490967,-0.02393937110900879,-0.02156245708465576,-0.01588499546051025,-0.007695674896240234,-0.0003379583358764648,0.003002524375915527,0.001860380172729492,5.841255187988281e-06,-0.00142204761505127,-0.001281380653381348,-0.0002686977386474609,-1.645088195800781e-05,-0.0001834630966186523,-0.0008230209350585938,-0.0005248785018920898,0.0002912282943725586,-0.001194596290588379,-0.004161596298217773,-0.006147503852844238,-0.008373379707336426,-0.01311647891998291,-0.01872265338897705,-0.02330243587493896,-0.02762711048126221,-0.03096103668212891,-0.03084135055541992,-0.02601218223571777,-0.01709532737731934,-0.005589127540588379,0.004671931266784668,0.009823083877563477,0.01175916194915771,0.0135352611541748,0.01561248302459717,0.01548194885253906,0.01211988925933838,0.005500674247741699,-0.001910805702209473,-0.005504965782165527,-0.006452441215515137,-0.004441976547241211,0.001093268394470215,0.00537407398223877,0.005091309547424316,0.003126740455627441,0.001192331314086914,-0.001974582672119141,-0.004349350929260254,-0.007699370384216309,-0.01255643367767334,-0.01697123050689697,-0.01979625225067139,-0.01741743087768555,-0.009425044059753418,-0.0007239580154418945,0.003678321838378906,0.004942655563354492,0.007455706596374512,0.01194500923156738,0.01671910285949707,0.01522016525268555,0.006482958793640137,-0.001844048500061035,-0.007977604866027832,-0.01517021656036377,-0.02074790000915527,-0.02259016036987305,-0.02372598648071289,-0.02282202243804932,-0.01446938514709473,-0.003392934799194336,0.002937793731689453,0.004385113716125488,0.005353450775146484,0.009048342704772949,0.01380562782287598,0.0141139030456543,0.0104830265045166,0.006461262702941895,0.003916740417480469,0.001836419105529785,-0.0005230903625488281,-0.002878069877624512,-0.006880760192871094,-0.01127684116363525,-0.01157581806182861,-0.01009023189544678,-0.009927272796630859,-0.009940981864929199,-0.0100252628326416,-0.01139366626739502,-0.01252174377441406,-0.01142382621765137,-0.0111992359161377,-0.01435303688049316,-0.01521384716033936,-0.01178574562072754,-0.007383823394775391,-0.004408121109008789,-0.001981019973754883,0.001685380935668945,0.004842162132263184,0.007419228553771973,0.009882211685180664,0.01049435138702393,0.01059865951538086,0.01034355163574219,0.007559776306152344,0.004350781440734863,0.002847909927368164,0.001113414764404297,-0.002831578254699707,-0.009817123413085938,-0.01672887802124023,-0.01920652389526367,-0.01701390743255615,-0.01379883289337158,-0.01196777820587158,-0.00902104377746582,-0.003344058990478516,0.002173542976379395,0.005515813827514648,0.00794672966003418,0.01059067249298096,0.01326608657836914,0.01225614547729492,0.00863802433013916,0.00516355037689209,0.001298427581787109,-0.00285041332244873,-0.005756497383117676,-0.008898138999938965,-0.0127328634262085,-0.01540195941925049,-0.01686704158782959,-0.0171276330947876,-0.01705920696258545,-0.01716339588165283,-0.01592469215393066,-0.01255393028259277,-0.009568929672241211,-0.005280256271362305,-0.0006974935531616211,0.0007499456405639648,0.002314329147338867,0.007664322853088379,0.01183366775512695,0.01319527626037598,0.01295638084411621,0.01174736022949219,0.01200973987579346,0.01538169384002686,0.01674580574035645,0.01420831680297852,0.008860230445861816,0.002934932708740234,-0.00257265567779541,-0.008330225944519043,-0.01406407356262207,-0.01826131343841553,-0.02004098892211914,-0.01888501644134521,-0.01680934429168701,-0.01453292369842529,-0.01146507263183594,-0.01002097129821777,-0.01094937324523926,-0.01223909854888916,-0.01130783557891846,-0.008986115455627441,-0.007979512214660645,-0.008016109466552734,-0.006972074508666992,-0.00397491455078125,-0.001516103744506836,0.0008183717727661133,0.004439949989318848,0.00596320629119873,0.003322720527648926,0.0006365776062011719,-0.0006232261657714844,-0.00320887565612793,-0.009385585784912109,-0.01691818237304688,-0.01995694637298584,-0.01720118522644043,-0.01251912117004395,-0.007724881172180176,-0.00380253791809082,-0.0001392364501953125,0.005437850952148438,0.009152054786682129,0.007389307022094727,0.004425883293151855,0.001821279525756836,-0.002714633941650391,-0.008187770843505859,-0.0137399435043335,-0.01879072189331055,-0.02107667922973633,-0.01890039443969727,-0.01513373851776123,-0.0131685733795166,-0.0115044116973877,-0.008789777755737305,-0.00416266918182373,0.003353357315063477,0.009915709495544434,0.01040279865264893,0.009290099143981934,0.01044356822967529,0.00872647762298584,0.003971695899963379,0.0004785060882568359,-0.004098892211914062,-0.01019132137298584,-0.01605963706970215,-0.02106785774230957,-0.02050983905792236,-0.01618170738220215,-0.01421463489532471,-0.01357114315032959,-0.009554505348205566,-0.003244996070861816,0.001273274421691895,0.003511428833007812,0.004163384437561035,0.00180661678314209,-0.0009714365005493164,-0.002794027328491211,-0.004272699356079102,-0.005444645881652832,-0.005132555961608887,-0.003071904182434082,-0.0005371570587158203,0.001512289047241211,0.001649141311645508,0.0009249448776245117,0.0004001855850219727,0.001228928565979004,0.001681089401245117,0.0007756948471069336,-0.001214981079101562,-0.003423810005187988,-0.005116939544677734,-0.009076833724975586,-0.01365542411804199,-0.01231265068054199,-0.008051156997680664,-0.006353974342346191,-0.005175352096557617,-0.004581093788146973,-0.006755590438842773,-0.00953972339630127,-0.01189517974853516,-0.01383829116821289,-0.01445162296295166,-0.01377367973327637,-0.01359224319458008,-0.0139535665512085,-0.01040410995483398,-0.004168033599853516,-0.0001066923141479492,0.003706812858581543,0.006972908973693848,0.00889122486114502,0.01208794116973877,0.0152972936630249,0.01519477367401123,0.01285469532012939,0.007228851318359375,-0.0009011030197143555,-0.007067322731018066,-0.01077425479888916,-0.01304829120635986,-0.01501357555389404,-0.01689934730529785,-0.01630866527557373,-0.01134562492370605,-0.003639459609985352,0.001304745674133301,0.0004076957702636719,-0.00192725658416748,-0.001567721366882324,-0.0001313686370849609,0.0008193254470825195,0.0002745389938354492,-0.002266883850097656,-0.005072832107543945,-0.006505370140075684,-0.006695151329040527,-0.004790782928466797,-0.00245368480682373,-0.005352139472961426,-0.01184678077697754,-0.01468300819396973,-0.01296460628509521,-0.01033973693847656,-0.007608771324157715,-0.004492998123168945,0.0008062124252319336,0.008744001388549805,0.01337242126464844,0.01270747184753418,0.01360082626342773,0.01802504062652588,0.01909410953521729,0.01392960548400879,0.004928231239318848,-0.003037929534912109,-0.007262110710144043,-0.008188247680664062,-0.008432745933532715,-0.007622241973876953,-0.006399273872375488,-0.006182432174682617,-0.005424022674560547,-0.00437164306640625,-0.002164483070373535,-0.0009435415267944336,-0.0003541707992553711,0.0006775856018066406,-0.0008666515350341797,-0.001382231712341309,0.002356529235839844,0.006744980812072754,0.00783848762512207,0.003693938255310059,-0.003066182136535645,-0.007552027702331543,-0.008161783218383789,-0.008194327354431152,-0.009031414985656738,-0.008677482604980469,-0.007955789566040039,-0.008254647254943848,-0.005860805511474609,-0.001283168792724609,-0.001568913459777832,-0.00637507438659668,-0.01211404800415039,-0.01628470420837402,-0.0194249153137207,-0.0217134952545166,-0.02118217945098877,-0.01652109622955322,-0.008243560791015625,-0.001153230667114258,0.004131793975830078,0.01024127006530762,0.01602935791015625,0.01980912685394287,0.02086043357849121,0.01753723621368408,0.009811997413635254,0.002502560615539551,-0.0009462833404541016,-0.004711270332336426,-0.0107119083404541,-0.01832997798919678,-0.02601563930511475,-0.0303657054901123,-0.02978956699371338,-0.02628219127655029,-0.0215994119644165,-0.01565039157867432,-0.01106548309326172,-0.00954902172088623,-0.009439706802368164,-0.007784724235534668,-0.0041630268096923]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>AR15</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
