<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>hw:2,0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ben/Desktop/senior_design/field_test/audio_recordings/drum</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>200</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>200</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0.354183554649353,-0.02245652675628662,-0.02647554874420166,0.2713279724121094,0.6690137386322021,0.7842532396316528,0.5832710266113281,0.2736164331436157,-0.1245177984237671,-0.4776842594146729,-0.6978453397750854,-0.9720937013626099,-1.308759212493896,-1.494055867195129,-1.546794533729553,-1.714788794517517,-2.133270263671875,-2.496824383735657,-2.55186653137207,-2.618214726448059,-2.962849617004395,-3.309235453605652,-3.565433621406555,-3.802563428878784,-3.816022753715515,-3.543039321899414,-3.318821668624878,-3.249624967575073,-3.186814069747925,-3.146313786506653,-3.140966534614563,-2.937608957290649,-2.518421530723572,-2.097822189331055,-1.836931228637695,-1.80440890789032,-1.908052682876587,-1.94028639793396,-1.620847105979919,-1.168341279029846,-1.195117235183716,-1.533226847648621,-1.410449266433716,-0.8951561450958252,-0.8003658056259155,-1.018330693244934,-0.7222287654876709,-0.1143404245376587,0.06434512138366699,0.02559900283813477,0.1959793567657471,0.1989158391952515,-0.08834338188171387,-0.02722334861755371,0.4185554981231689,0.5582417249679565,0.3097747564315796,0.2035689353942871,0.2350977659225464,0.04790103435516357,-0.2715414762496948,-0.3488963842391968,-0.1290292739868164,0.1867772340774536,0.4480866193771362,0.4564583301544189,0.1998599767684937,0.03638792037963867,0.1153897047042847,0.2325732707977295,0.3907023668289185,0.5538836717605591,0.7950378656387329,1.3351811170578,1.86743438243866,1.94712495803833,1.652263283729553,1.192777276039124,0.8655145168304443,0.8905148506164551,0.9967002868652344,0.915685772895813,0.8295471668243408,0.7898011207580566,0.6736164093017578,0.6635355949401855,0.9517346620559692,1.363772392272949,1.598383069038391,1.625781297683716,1.712288975715637,2.081149578094482,2.517544984817505,2.592742323875427,2.281997680664062,1.962337374687195,1.908681392669678,2.077040433883667,2.224193930625916,2.086418509483337,1.693023204803467,1.198106288909912,0.7788619995117188,0.5582245588302612,0.5576226711273193,0.8445171117782593,1.296378135681152,1.571836709976196,1.715852022171021,1.854126334190369,1.609960556030273,0.9216563701629639,0.3059649467468262,0.0737682580947876,0.1175311803817749,0.24109947681427,0.4166232347488403,0.5619345903396606,0.4660574197769165,0.1043851375579834,-0.3280255794525146,-0.5680038928985596,-0.4977772235870361,-0.2808980941772461,-0.2496052980422974,-0.4705034494400024,-0.5521198511123657,-0.3335670232772827,-0.1702290773391724,-0.1730625629425049,-0.05519771575927734,0.1460731029510498,-0.04700624942779541,-0.5162233114242554,-0.7089443206787109,-0.7182719707489014,-0.8801958560943604,-0.9664771556854248,-0.7161991596221924,-0.5135883092880249,-0.655208945274353,-0.9916770458221436,-1.230611443519592,-1.182804822921753,-0.8176188468933105,-0.4935243129730225,-0.5965211391448975,-0.9006707668304443,-1.166663289070129,-1.316744685173035,-1.088529467582703,-0.7715706825256348,-0.6379977464675903,-0.4465320110321045,-0.108864426612854,0.2622663974761963,0.7255021333694458,1.210126876831055,1.473354578018188,1.462061405181885,1.232623100280762,1.00234043598175,0.9088482856750488,0.7457002401351929,0.4191176891326904,0.2895530462265015,0.569092869758606,0.9931994676589966,1.193687081336975,0.9709736108779907,0.6103774309158325,0.6228024959564209,1.09532618522644,1.410698175430298,1.32275927066803,1.129197120666504,0.9739927053451538,0.8769353628158569,0.8699133396148682,0.8030362129211426,0.4825379848480225,0.210138201713562,-0.01151525974273682,-0.3463236093521118,-0.5353463888168335,-0.3881113529205322,-0.3191721439361572,-0.4956936836242676,-0.6904703378677368,-0.7464684247970581,-0.7465724945068359,-0.8139152526855469,-0.839255690574646,-0.8851826190948486,-1.114652037620544,-1.352097272872925,-1.309452295303345,-1.286613821983337,-1.446099042892456,-1.476632237434387,-1.412018895149231,-1.529817223548889,-1.667754650115967,-1.580873608589172,-1.318754196166992,-1.068004131317139,-0.9285045862197876,-0.8169000148773193,-0.8203847408294678,-0.9782799482345581,-1.07275915145874,-1.063132166862488,-1.129098415374756,-1.234241008758545,-1.180415511131287,-0.918857216835022,-0.612987756729126,-0.5323820114135742,-0.4887317419052124,-0.180925726890564,0.1656135320663452,0.2734694480895996,0.2915539741516113,0.2436035871505737,0.1026417016983032,-0.02740788459777832,-0.1807336807250977,-0.3580963611602783,-0.5999307632446289,-1.033096790313721,-1.413483381271362,-1.444679617881775,-1.276805520057678,-1.123441100120544,-1.042121887207031,-0.9922327995300293,-0.8402223587036133,-0.4505435228347778,0.0387042760848999,0.2898834943771362,-0.003398895263671875,-0.5573222637176514,-0.9073623418807983,-1.1633620262146,-1.55365777015686,-1.835037589073181,-1.801221370697021,-1.699294209480286,-1.669881105422974,-1.531752705574036,-1.240159034729004,-1.064122438430786,-1.028711915016174,-0.7883130311965942,-0.3720545768737793,-0.05565154552459717,0.1435400247573853,0.1525211334228516,-0.08987867832183838,-0.3050583600997925,-0.1350942850112915,0.363672137260437,0.7093359231948853,0.6487298011779785,0.6293030977249146,0.7664616107940674,0.479778528213501,-0.04588937759399414,-0.1476598978042603,-0.1191812753677368,-0.4066647291183472,-0.6008641719818115,-0.5589509010314941,-0.5939075946807861,-0.4711654186248779,-0.1957347393035889,-0.1867117881774902,-0.1250134706497192,0.0665895938873291,-0.06594157218933105,-0.2343467473983765,0.01915204524993896,0.5884809494018555,0.8640435934066772,0.5318230390548706,0.08682417869567871,-0.04362881183624268,0.01301407814025879,0.1607083082199097,0.5291515588760376,0.7686159610748291,0.7200486660003662,0.7696620225906372,0.9331115484237671,0.9827066659927368,0.9197820425033569,0.7621368169784546,0.6282098293304443,0.8825089931488037,1.515149831771851,1.994935870170593,2.004691600799561,1.712603330612183,1.439265847206116,1.295414686203003,1.261640310287476,1.350086688995361,1.598148107528687,1.828953266143799,2.055079579353333,2.348758935928345,2.464441537857056,2.307552695274353,2.1749507188797,2.31456184387207,2.423101186752319,2.379459500312805,2.440877795219421,2.371687531471252,1.861729860305786,1.303428053855896,1.080976366996765,1.080571889877319,1.154135227203369,1.244963407516479,1.370838403701782,1.545669078826904,1.665453314781189,1.536825299263,1.063573122024536,0.384422779083252,-0.137654185295105,-0.3314362764358521,-0.2823357582092285,0.1166846752166748,0.8115227222442627,1.163416743278503,0.9199762344360352,0.5064386129379272,0.2447118759155273,-0.06573235988616943,-0.4383491277694702,-0.4753882884979248,-0.265045166015625,-0.2304146289825439,-0.2465733289718628,-0.1818966865539551,-0.1245102882385254,0.1127310991287231,0.4942667484283447,0.5598328113555908,0.416980504989624,0.5960640907287598,1.170522451400757,1.50184178352356,1.349749803543091,1.067706942558289,0.8762519359588623,0.6031558513641357,0.08401751518249512,-0.2568987607955933,0.0003229379653930664,0.5024957656860352,0.7273796796798706,0.7837092876434326,0.9529030323028564,1.042045712471008,0.627294659614563,-0.1193228960037231,-0.6524677276611328,-0.8818212747573853,-1.048367142677307,-1.134196758270264,-1.164291143417358,-1.576399683952332,-2.297491192817688,-2.843288540840149,-3.014757871627808,-3.019180297851562,-3.117831945419312,-3.248583197593689,-3.200470805168152,-3.017140746116638,-2.856819748878479,-2.671505928039551,-2.485061287879944,-2.484940052032471,-2.478752732276917,-2.220136284828186,-1.878005504608154,-1.682461738586426,-1.699815630912781,-1.791860461235046,-1.849736094474792,-1.848784446716309,-1.635596036911011,-1.215966582298279,-0.7060003280639648,-0.2551606893539429,0.09434723854064941,0.4363353252410889,0.7512953281402588,0.9418984651565552,0.874786376953125,0.6859610080718994,0.552861213684082,0.5201210975646973,0.5089598894119263,0.2686790227890015,-0.2162665128707886,-0.7296938896179199,-1.039626359939575,-1.092816710472107,-0.8364790678024292,-0.1062519550323486,0.6928982734680176,0.8306962251663208,0.4536377191543579,0.1432192325592041,-0.06933295726776123,-0.4258435964584351,-0.8126331567764282,-1.135263204574585,-1.422954797744751,-1.504461765289307,-1.34028697013855,-1.13844108581543,-0.9703706502914429,-0.8883090019226074,-0.975185751914978,-1.229748845100403,-1.436695218086243,-1.430492877960205,-1.153923869132996,-0.727544903755188,-0.5103932619094849,-0.512661337852478,-0.4878358840942383,-0.6382477283477783,-1.160213112831116,-1.454711079597473,-0.8642667531967163,0.1480171680450439,0.8815637826919556,1.354325652122498,1.548353433609009,1.412394404411316,1.286643862724304,1.348204851150513,1.29428493976593,1.105700969696045,0.8830744028091431,0.3823875188827515,-0.1678462028503418,-0.3060357570648193,-0.4766339063644409,-0.9359128475189209,-1.123051643371582,-0.7977232933044434,-0.396181583404541,-0.2277592420578003,-0.1711045503616333,-0.03019094467163086,0.1253235340118408,0.051460862159729,-0.2781364917755127,-0.6808186769485474,-0.881477952003479,-0.7091953754425049,-0.4495489597320557,-0.321200966835022,-0.08533716201782227,0.1044151782989502,-0.03966021537780762,-0.160499095916748,0.04031896591186523,0.1058120727539062,-0.04527461528778076,0.2088743448257446,0.8318699598312378,1.059190392494202,0.6029412746429443,-0.04351401329040527,-0.7002689838409424,-1.418980836868286,-1.719515919685364,-1.178959608078003,-0.1236873865127563,0.5569038391113281,0.4981076717376709,0.05632853507995605,-0.3193320035934448,-0.1336802244186401,0.6081640720367432,1.416635513305664,2.209786176681519,2.924866318702698,2.993997573852539,2.590899109840393,2.337564468383789,2.079148650169373,1.588249683380127,1.140681266784668,1.004711508750916,1.00151002407074,0.9556227922439575,0.9256399869918823,0.8611704111099243,0.8591265678405762,0.9057036638259888,0.6756108999252319,0.3668789863586426,0.4439678192138672,0.6184862852096558,0.5430604219436646,0.4601919651031494,0.3068071603775024,-0.09396421909332275,-0.4360295534133911,-0.5808323621749878,-0.4155385494232178,-0.1159079074859619,-0.1535736322402954,-0.4558446407318115,-0.6894242763519287,-0.7840762138366699,-0.7519004344940186,-0.5993696451187134,-0.4818631410598755,-0.4333333969116211,-0.4858113527297974,-0.8160814046859741,-1.430513262748718,-2.357394576072693,-3.146407127380371,-3.061317801475525,-2.232351064682007,-1.266362071037292,-0.5728554725646973,-0.3030059337615967,-0.472186803817749,-0.8952183723449707,-1.070671319961548,-0.6829204559326172,-0.06692647933959961,0.3854098320007324,0.7723013162612915,1.163217186927795,1.313837170600891,1.064360618591309,0.5691690444946289,0.3800979852676392,0.8559218645095825,1.278647661209106,1.189525365829468,1.234400868415833,1.502259135246277,1.550905823707581,1.442092895507812,1.305884957313538,1.030681729316711,0.4560227394104004,-0.3432819843292236,-0.7651269435882568,-0.5804396867752075,-0.5490374565124512,-1.004723310470581,-1.505204200744629,-1.959324717521667,-2.372796893119812,-2.558945417404175,-2.402055501937866,-2.194382786750793,-2.221313238143921,-2.225374102592468,-2.005016684532166,-1.703993439674377,-1.429871678352356,-1.148647427558899,-0.888968825340271,-0.7814154624938965,-0.8091269731521606,-0.8713864088058472,-0.9532474279403687,-1.064372420310974,-1.289491295814514,-1.475466012954712,-1.507517337799072,-1.246667146682739,-0.756584644317627,-0.4649180173873901,-0.3315060138702393,0.2555136680603027,1.349719762802124,2.26413094997406,2.54373300075531,2.41129732131958,2.082641959190369,1.58593761920929,1.196279168128967,1.176159381866455,1.417144060134888,1.504461765289307,1.548457503318787,1.896522402763367,2.005335330963135,1.422582507133484,0.9388139247894287,1.145483493804932,1.339209794998169,1.279860019683838,1.391388416290283,1.220881462097168,0.5476148128509521,-0.0306168794631958,-0.2480871677398682,-0.2765754461288452,-0.2378314733505249,-0.2503520250320435,-0.355656623840332,-0.374059796333313,-0.2694032192230225,-0.3282841444015503,-0.6058477163314819,-0.7435727119445801,-0.5823386907577515,-0.383047342300415,-0.2230428457260132,0.03149878978729248,0.2604124546051025,0.6624155044555664,1.310243010520935,1.700785517692566,1.659900069236755,1.281639933586121,0.7355217933654785,0.4836623668670654,0.5299454927444458,0.6352436542510986,0.8698339462280273,1.07879626750946,1.035802602767944,1.038494467735291,1.150580763816833,1.02952516078949,0.7558711767196655,0.7924908399581909,1.382128357887268,1.883092045783997,1.627703905105591,0.9989469051361084,0.7033041715621948,0.469841480255127,0.06479036808013916,-0.2220643758773804,-0.3037108182907104,-0.5564661026000977,-1.118231177330017,-1.69703471660614,-1.981677174568176,-1.935457348823547,-2.016928911209106,-2.311284184455872,-2.395466923713684,-2.10736870765686,-1.946089625358582,-2.265609383583069,-2.579143524169922,-2.357758283615112,-1.995885372161865,-1.825636982917786,-1.547324538230896,-1.19955039024353,-1.218640208244324,-1.571741223335266,-1.557629585266113,-1.14501678943634,-0.9912950992584229,-1.160237789154053,-1.160580039024353,-0.8170255422592163,-0.2749961614608765,0.1118320226669312,0.09794247150421143,-0.1851367950439453,-0.2081372737884521,0.1783154010772705,0.4726771116256714,0.6523904800415039,0.8975100517272949,0.5349537134170532,-0.5346500873565674,-1.204183101654053,-1.219147682189941,-1.192939281463623,-1.446764230728149,-1.817695498466492,-1.964297533035278,-1.73813259601593,-1.313101172447205,-0.874812126159668,-0.7149385213851929,-0.9742072820663452,-1.251919984817505,-1.578272938728333,-2.143092513084412,-2.440080642700195,-2.246333956718445,-1.891642928123474,-1.457589626312256,-0.9754968881607056,-0.7727057933807373,-0.9259650707244873,-1.338378310203552,-1.62782621383667,-1.123942136764526,0.1283072233200073,1.296384572982788,1.77074933052063,1.566175103187561,1.070677757263184,0.6909273862838745,0.3381696939468384,-0.07082533836364746,-0.3922752141952515,-0.6417582035064697,-0.812214732170105,-0.8438304662704468,-0.8020298480987549,-0.7127530574798584,-0.7177634239196777,-1.002046465873718,-1.151597857475281,-1.166700839996338,-1.274185538291931,-1.142184376716614,-0.6409664154052734,-0.5025590658187866,-0.945298433303833,-1.139244675636292,-0.9005377292633057,-0.8700249195098877,-1.175970554351807,-1.170369029045105,-0.4251730442047119,0.3740887641906738,0.7396180629730225,1.164017558097839,1.789906740188599,2.116180300712585,2.201215982437134,2.65114152431488,3.353958606719971,3.865896821022034,4.311823725700378,4.912298440933228,5.564648151397705,5.869895339012146,5.471905946731567,4.932955741882324,5.070983290672302,5.506092309951782,5.437457799911499,5.01800000667572,4.337724208831787,3.186434268951416,2.486522555351257,2.663110613822937,2.750712633132935,2.555647373199463,2.574159979820251,2.319558262825012,1.473603487014771,0.8389627933502197,0.6958036422729492,0.5946575403213501,0.4299355745315552,0.596184253692627,0.8773452043533325,0.8992331027984619,0.818281888961792,0.8429796695709229,0.6258001327514648,-0.004605889320373535,-0.2702100276947021,0.1068710088729858,0.2715339660644531,-0.2623575925827026,-1.082897901535034,-1.889174222946167,-2.50813364982605,-2.836813688278198,-2.898542046546936,-2.681089997291565,-2.496872663497925,-2.289628028869629,-1.855113387107849,-1.51215648651123,-1.508010864257812,-1.594521760940552,-1.551393985748291,-1.492729783058167,-1.558303356170654,-1.702328324317932,-1.623639822006226,-1.34127938747406,-1.230908632278442,-1.565732002258301,-2.061296939849854,-2.048208832740784,-1.827921152114868,-2.07292914390564,-2.449031710624695,-2.299355864524841,-1.776728510856628,-1.529511451721191,-1.522899270057678,-1.407365798950195,-1.285062432289124,-1.260147929191589,-1.262628436088562,-1.326378107070923,-1.57599949836731,-2.247570991516113,-3.126039505004883,-3.553155541419983,-3.423396706581116,-3.069716334342957,-2.73380720615387,-2.515820860862732,-2.47662091255188,-2.231534600257874,-1.836828231811523,-1.790687799453735,-1.816290020942688,-1.419078469276428,-0.9740334749221802,-0.850342869758606,-0.8969564437866211,-1.237848043441772,-1.719176888465881,-1.939006447792053,-1.968498945236206,-1.879920601844788,-1.550247073173523,-1.239626884460449,-1.161666870117188,-0.8913463354110718,-0.2430456876754761,0.3353147506713867,0.5853888988494873,0.5757479667663574,0.4762219190597534,0.3504348993301392,0.3859333992004395,0.8476531505584717,1.495186686515808,1.766036152839661,1.435630917549133,0.6213390827178955,-0.2737923860549927,-0.9239609241485596,-1.116543531417847,-0.6887869834899902,0.05499494075775146,0.6664237976074219,1.142264842987061,1.462486267089844,1.580559253692627,1.476386547088623,1.217409610748291,1.068920373916626,0.793138861656189,0.2561327219009399,-0.1107505559921265,-0.1566517353057861,-0.1569060087203979,-0.2358595132827759,-0.186866283416748,0.2209732532501221,0.8605062961578369,1.481312155723572,1.786072254180908,1.800846934318542,1.913821578025818,2.201624751091003,2.344141244888306,2.051093816757202,1.519036889076233,0.9387935400009155,0.07923030853271484,-0.8841869831085205,-1.423580288887024,-1.820281147956848,-2.483797430992126,-2.806314826011658,-2.111993908882141,-1.132611036300659,-0.6222306489944458,-0.3056430816650391,-0.2346460819244385,-0.6101585626602173,-0.9200674295425415,-0.7812845706939697,-0.2345151901245117,0.3748290538787842,0.4401472806930542,0.2560672760009766,0.3427734375,0.4357473850250244,0.4896318912506104,0.3672223091125488,0.2131390571594238,0.4952613115310669,0.8293529748916626,0.6389762163162231,0.4553993940353394,0.5351157188415527,0.2894822359085083,-0.1631244421005249,-0.1817840337753296,0.2448438405990601,0.06522274017333984,-0.6961179971694946,-0.6962424516677856,0.05028390884399414,0.4326092004776001,0.3195412158966064,0.309440016746521,0.3963124752044678,0.2814162969589233,0.3300962448120117,0.6801577806472778,0.6929315328598022,0.01677238941192627,-0.6108505725860596,-0.5030354261398315,-0.1698482036590576,-0.2263258695602417,-0.3285984992980957,-0.2790119647979736,-0.3351613283157349,-0.1931308507919312,0.3931013345718384,0.9106442928314209,1.346459269523621,1.928511500358582,2.266643643379211,2.058371186256409,1.518377065658569,1.134662389755249,0.9012951850891113,0.567119836807251,0.1947476863861084,-0.1153006553649902,-0.1714811325073242,0.1746826171875,0.7370764017105103,1.478231906890869,2.199016571044922,2.404058575630188,2.232073187828064,2.083689093589783,1.826849341392517,1.548163533210754,1.362144827842712,1.173584461212158,0.8241033554077148,0.02451860904693604,-1.049659967422485,-1.840017914772034,-1.996057033538818,-1.746997833251953,-1.556869983673096,-1.436460256576538,-1.280458688735962,-0.8353085517883301,-0.252760648727417,-0.2053467035293579,-0.406569242477417,-0.02238035202026367,0.5058377981185913,0.2272474765777588,-0.3180724382400513,-0.3073554039001465,-0.03466165065765381,0.257878303527832,0.520653247833252,0.5131881237030029,0.3628299236297607,0.3594074249267578,0.63780677318573,1.048155784606934,1.303742408752441,1.380913853645325,1.389464735984802,1.220982313156128,0.85978102684021,0.4388576745986938,-0.05476212501525879,-0.542273998260498,-0.6412550210952759,-0.5431677103042603,-0.7177988290786743,-1.002482056617737,-0.9702376127243042,-0.5930149555206299,0.293958306312561,1.522221207618713,2.365845680236816,2.625179886817932,2.477349400520325,1.328768491744995,-0.1633197069168091,-0.6015872955322266,-0.5206253528594971,-0.5895473957061768,-0.3096953630447388,0.310288667678833,0.2875843048095703,-0.295482873916626,-0.5702794790267944,-0.4025920629501343,-0.5117901563644409,-0.906296968460083,-0.8619621992111206,-0.2496203184127808,0.04779911041259766,-0.1368999481201172,-0.5651618242263794,-1.18267285823822,-1.563061594963074,-1.63507354259491,-1.846154808998108,-2.175076246261597,-1.984111547470093,-1.257562279701233,-0.5044612884521484,-0.02740681171417236,0.09680414199829102,-0.148091197013855,-0.4298347234725952,-0.4918431043624878,-0.4330555200576782,-0.3331775665283203,-0.01054537296295166,0.2240363359451294,-0.2955805063247681,-1.334086775779724,-1.93734884262085,-1.780096292495728,-1.335929989814758,-0.8168635368347168,-0.3059091567993164,-0.03628385066986084,-0.07876896858215332,-0.06550705432891846,0.01374149322509766,-0.01926147937774658,-0.1289026737213135,-0.4314333200454712,-0.893962025642395,-1.298215985298157,-1.818341374397278,-2.585706353187561,-2.949872016906738,-2.462120890617371,-2.132484912872314,-2.206965565681458,-1.481613636016846,-0.2568451166152954,0.3706265687942505,0.7324512004852295,1.189806461334229,1.038627505302429,0.4832965135574341,0.3731628656387329,0.4703071117401123,0.1632682085037231,-0.5844061374664307,-1.284265279769897,-1.781177759170532,-2.143765211105347,-2.169746160507202,-1.955084681510925,-1.637646317481995,-0.611289381980896,0.7636206150054932,1.422175884246826,1.609966993331909,1.850078344345093,1.814076662063599,1.547420024871826,1.716365933418274,2.154734373092651,2.188009858131409,1.9675612449646,2.147394776344299,2.438096880912781,2.181339740753174,1.756876945495605,1.40205180644989,0.8732618093490601,0.5365662574768066,0.8632968664169312,1.576438307762146,2.511821150779724,2.996222734451294,1.894545078277588,0.2768125534057617,-0.2996714115142822,-0.6566369533538818,-1.550837159156799,-2.01793098449707,-1.80466639995575,-1.319488048553467,-0.8315985202789307,-0.4598261117935181,-0.3806365728378296,-0.4689649343490601,0.07440340518951416,1.27796745300293,2.127257823944092,2.202234148979187,2.047319412231445,1.619100451469421,0.5338336229324341,-0.6731207370758057,-1.479040861129761,-2.051843762397766,-2.3116854429245,-1.717043995857239,-0.5001289844512939,0.3529400825500488,0.7438473701477051,0.7286456823348999,0.3394432067871094,0.1973387002944946,0.5646382570266724,0.6280810832977295,0.03486871719360352,-0.3338019847869873,-0.2501063346862793,-0.3607109785079956,-0.60709547996521,-0.5582116842269897,-0.6036547422409058,-0.7785798311233521,-0.5404404401779175,-0.4728884696960449,-0.9895581007003784,-1.149556159973145,-0.8993854522705078,-1.294427633285522,-2.095254778862,-2.63581645488739,-2.789301037788391,-2.776321291923523,-2.641854643821716,-2.731695771217346,-3.261712074279785,-3.650114178657532,-3.711909055709839,-3.905746936798096,-4.083199739456177,-3.657755255699158,-3.008937478065491,-2.353041887283325,-1.485242128372192,-1.257580518722534,-1.909641623497009,-2.333725690841675,-1.980915427207947,-1.543405294418335,-1.433910012245178,-1.20404577255249,-0.6591013669967651,0.3507267236709595,1.297345876693726,1.699848890304565,1.718761682510376,1.726811528205872,1.979885458946228,2.551123023033142,3.409659504890442,4.14135754108429,4.35687518119812,3.980209350585938,3.33035409450531,2.589912056922913,1.679567098617554,0.4523706436157227,-0.6872838735580444,-1.121869325637817,-0.7783362865447998,3.218650817871094e-06,0.9204032421112061,1.81098997592926,2.610758185386658,3.27368438243866,3.647271037101746,3.699859499931335,3.499174475669861,3.415661215782166,3.495115756988525,3.092077374458313,2.027940988540649,0.2118816375732422,-1.651556253433228,-2.525613069534302,-2.599146366119385,-2.481819033622742,-2.137532830238342,-1.552627801895142,-1.135882258415222,-0.7677168846130371,-0.01760601997375488,0.6091436147689819,0.3534668684005737,-0.3317055702209473,-0.4321231842041016,-0.1831895112991333,-0.09055459499359131,0.1105209589004517,0.1278641223907471,-0.1944000720977783,-0.1513838768005371,0.4710624217987061,0.8437693119049072,0.934037446975708,1.277255058288574,1.472340703010559,0.9167865514755249,0.03197193145751953,-0.6409685611724854,-1.468667149543762,-2.040802717208862,-1.721393465995789,-1.016782522201538,-0.4667751789093018,0.2523068189620972,1.136856436729431,1.036720991134644,0.09821176528930664,-0.7819797992706299,-1.199478507041931,-1.05562949180603,-0.5312833786010742,0.1372078657150269,0.3313729763031006,-0.2746807336807251,-1.201526641845703,-1.915876150131226,-2.552039265632629,-2.675691246986389,-1.793164014816284,-0.8598915338516235,-0.4470072984695435,-0.0472337007522583,0.3403412103652954,0.4555732011795044,0.377979040145874,0.2039905786514282,0.3213522434234619,1.011474967002869,2.093647599220276,2.751460433006287,2.275723457336426,1.178848028182983,0.1304175853729248,-0.5428426265716553,-0.4530926942825317,0.3777526617050171,0.9579155445098877,0.7721918821334839,0.7004878520965576,0.9115712642669678,1.011836528778076,0.7775745391845703,0.2665364742279053,-0.1432610750198364,-0.2134040594100952,0.2619069814682007,0.9350663423538208,1.203927755355835,0.6260243654251099,-0.9610430002212524,-2.573931455612183,-2.923035979270935,-2.304110884666443,-2.227336406707764,-2.790601372718811,-2.793958425521851,-2.18248450756073,-1.902753710746765,-2.152626156806946,-2.139226913452148,-1.544405221939087,-1.177980065345764,-1.587749719619751,-1.60221540927887,-0.9848449230194092,-1.056480288505554,-1.829478979110718,-2.119791626930237,-2.055758714675903,-2.309187769889832,-1.848770499229431,-0.6323490142822266,-0.238304615020752,-0.7625112533569336,-1.214257478713989,-1.285149335861206,-0.9864778518676758,-0.2209721803665161,0.193583607673645,-0.08487904071807861,-0.1510040760040283,0.1749798059463501,0.05339312553405762,-0.7722326517105103,-1.536887526512146,-1.482765913009644,-0.6305562257766724,0.1559661626815796,0.4285236597061157,0.6610068082809448,0.9374299049377441,0.7778234481811523,0.5249136686325073,0.5311471223831177,0.6557464599609375,0.7979464530944824,1.012792468070984,1.520301818847656,2.500380992889404,3.314075231552124,3.23286759853363,2.637977242469788,2.221705913543701,2.14032769203186,2.366363883018494,2.379016399383545,1.991057395935059,1.852393627166748,2.034598231315613,1.83642590045929,1.339337468147278,1.148572325706482,1.198964595794678,1.249433040618896,1.274270296096802,1.056348323822021,0.7759823799133301,0.6008791923522949,0.403522253036499,0.1732621192932129,-0.1254973411560059,-0.4497431516647339,-0.5967764854431152,-0.5846883058547974,-0.5458939075469971,-0.004260420799255371,0.8436877727508545,1.09808886051178,1.046646237373352,1.091959476470947,0.8371345996856689,0.5328851938247681,0.5409114360809326,0.2953841686248779,-0.001014947891235352,0.4853907823562622,1.198243618011475,1.143741130828857,0.6032373905181885,0.1945985555648804,-0.2889640331268311,-0.6937050819396973,-0.677680492401123,-0.2857464551925659,0.570490837097168,1.693989872932434,1.642756462097168,-0.128415584564209,-1.653418779373169,-2.002557635307312,-2.057801485061646,-1.966317772865295,-1.711287975311279,-1.667095899581909,-1.485759258270264,-1.071864366531372,-1.353356838226318,-2.013251066207886,-2.404177665710449,-2.987380027770996,-3.288841009140015,-2.805727958679199,-2.148901104927063,-1.787513136863708,-1.778179049491882,-2.106400966644287,-2.144500136375427,-1.535125851631165,-1.123554825782776,-0.9091368913650513,-0.2690545320510864,0.2564159631729126,0.4809308052062988,0.7491860389709473,0.9692409038543701,0.8772497177124023,0.4516164064407349,-0.09344279766082764,-0.3261491060256958,-0.06666254997253418,0.25932776927948,0.728344202041626,1.130099415779114,1.066158771514893,1.161875009536743,1.90342104434967,2.474431157112122,2.251660823822021,1.697504639625549,1.589009284973145,2.161854028701782,2.591833591461182,2.437628030776978,2.178435444831848,1.765742182731628,1.03322446346283,0.3864161968231201,0.02480185031890869,-0.2584576606750488,-0.4298669099807739,-0.2786310911178589,-0.1465108394622803,-0.09046661853790283,-0.01775515079498291,-0.2591046094894409,-0.4019150733947754,-0.196455717086792,-0.4334911108016968,-1.078039884567261,-1.437146902084351,-1.844183921813965,-2.22173273563385,-2.323614835739136,-2.761482238769531,-3.607810378074646,-3.974604606628418,-3.920131087303162,-3.943046808242798,-3.560770869255066,-2.468245983123779,-1.184127688407898,-0.3723635673522949,0.05744004249572754,0.1101014614105225,0.183397650718689,0.2860715389251709,0.2143610715866089,0.2105834484100342,0.5944976806640625,1.077010989189148,1.216911792755127,1.147900700569153,0.7325477600097656,0.1616889238357544,0.2759639024734497,1.266573429107666,2.1218022108078,2.250872254371643,2.616542100906372,3.494404435157776,3.831029176712036,3.724193572998047,3.893725275993347,3.67427659034729,3.010883688926697,2.73923921585083,2.323011875152588,1.596466898918152,1.455294728279114,1.897365689277649,2.107458829879761,2.118160843849182,1.967643857002258,1.294714093208313,0.5353667736053467,0.2831082344055176,0.05143618583679199,-0.6322824954986572,-0.9423673152923584,-0.4132125377655029,0.2236061096191406,0.3592454195022583,-0.01427364349365234,-0.2440649271011353,0.020774245262146,0.205070972442627,-0.0963599681854248,-0.4548414945602417,-1.123480796813965,-2.194414973258972,-2.689213871955872,-2.520249724388123,-2.257616400718689,-1.988110184669495,-1.985644698143005,-2.537889003753662,-3.065417289733887,-3.166599869728088,-3.04455828666687,-2.600476741790771,-2.411782264709473,-2.673919916152954,-2.649029016494751,-2.502163052558899,-2.41110098361969,-1.838986873626709,-1.089509010314941,-1.054772257804871,-1.258409857749939,-1.450734972953796,-1.992601275444031,-2.300911545753479,-2.050509095191956,-1.926121115684509,-2.080131411552429,-2.035908222198486,-1.693871855735779,-1.119583010673523,-0.4904054403305054,-0.1999479532241821,-0.1930482387542725,-0.4475523233413696,-0.9460837841033936,-0.8347549438476562,-0.3369133472442627,-0.2966523170471191,-0.04934942722320557,0.5993374586105347,0.4286481142044067,-0.1560745239257812,0.02217435836791992,0.4060242176055908,0.707893967628479,0.685871958732605,0.2766162157058716,0.2068830728530884,0.5535660982131958,0.9345567226409912,1.433711528778076,2.178494453430176,2.524211883544922,1.729185819625854,0.3154599666595459,-0.5456578731536865,-0.2671726942062378,0.2029112577438354,-0.1107569932937622,-0.7965205907821655,-1.307157397270203,-1.376729607582092,-0.8658889532089233,0.1896944046020508,1.045883417129517,1.23595118522644,1.338726997375488,1.394277691841125,1.168115973472595,0.5615859031677246,-0.03155028820037842,-0.3830795288085938,-0.6869008541107178,-0.6171258687973022,0.04279518127441406,0.6377735137939453,0.6339980363845825,0.5118438005447388,0.4747424125671387,0.6456012725830078,1.339383602142334,1.64306116104126,0.9076927900314331,0.3058662414550781,0.5948173999786377,0.6763061285018921,0.0686945915222168,-0.3733946084976196,-0.4599162340164185,-0.5597126483917236,-0.4165341854095459,-0.3050519227981567,-0.5070501565933228,-0.5304518938064575,-0.6825814247131348,-1.16435444355011,-0.9725035429000854,-0.008491873741149902,-0.0006598234176635742,-1.015024065971375,-1.056953430175781,-0.03988552093505859,0.7135502099990845,1.306408524513245,1.579119443893433,1.235611081123352,0.8720988035202026,0.1999082565307617,-0.6731014251708984,-0.3704860210418701,0.66472327709198,1.330106377601624,1.843544483184814,2.379680514335632,2.718193531036377,2.964295864105225,3.047510862350464,2.797717809677124,2.220216751098633,1.202531933784485,0.5886526107788086,0.4520798921585083,0.2903459072113037,0.5094952583312988,1.109502196311951,1.145135879516602,0.2742526531219482,-0.3282562494277954,-0.06186890602111816,0.1787831783294678,0.1222851276397705,0.3733227252960205,0.5658431053161621,0.4342303276062012,0.2257454395294189,-0.7900768518447876,-2.164898872375488,-2.730355739593506,-2.920534014701843,-3.148394107818604,-2.742172479629517,-1.967278003692627,-1.770422101020813,-1.816423058509827,-1.544390201568604,-1.269752383232117,-1.107262015342712,-1.241116046905518,-1.806659817695618,-2.130983948707581,-1.519047617912292,-0.4088512659072876,-0.114208459854126,-1.237261176109314,-2.665901184082031,-2.648325204849243,-1.343964815139771,-0.6374301910400391,-0.4450632333755493,0.409140944480896,0.9323819875717163,0.7085087299346924,1.070546865463257,1.936119318008423,2.113660097122192,1.628204941749573,0.7923234701156616,0.1936941146850586,-0.2177653312683105,-0.9553534984588623,-1.136189103126526,-0.8138937950134277,-0.5236626863479614,-0.03832447528839111,1.03141450881958,1.748095393180847,2.16786003112793,3.117683887481689,3.594768404960632,3.047920703887939,2.123340725898743,1.246643543243408,0.5248557329177856,0.1378269195556641,0.4380379915237427,1.080827236175537,1.165861845016479,0.4071571826934814,-0.4716761112213135,-0.653485894203186,-0.7316776514053345,-0.4106537103652954,0.8379875421524048,2.183544516563416,2.316471576690674,1.735328078269958,1.57853901386261,1.566433668136597,0.9178690910339355,-0.02452933788299561,-0.3271629810333252,-0.495008111000061,-1.519552946090698,-2.330932974815369,-2.335890769958496,-2.504831314086914,-2.528361797332764,-1.961836338043213,-1.647177815437317,-0.9793624877929688,0.3436875343322754,0.7874901294708252,0.817381739616394,1.695239782333374,2.180576920509338,0.9130207300186157,-0.07389914989471436,0.2716240882873535,0.0750192403793335,-0.9202187061309814,-1.103835225105286,-0.8099809885025024,-1.284999132156372,-1.387208461761475,-0.6858944892883301,-0.04196369647979736,0.9268856048583984,1.449446439743042,0.429440975189209,0.1837002038955688,1.787742733955383,2.389360070228577,1.267264366149902,0.1509289741516113,-0.4306308031082153,-0.4978437423706055,-0.164569616317749,0.003814101219177246,0.02374505996704102,-0.1157158613204956,0.01007437705993652,0.6386135816574097,1.101338624954224,0.8829853534698486,0.01857161521911621,-0.8262491226196289,-1.213887333869934,-1.621269822120667,-2.126625895500183,-2.263236165046692,-2.169044494628906,-1.347615838050842,0.1128126382827759,0.9615440368652344,1.059689283370972,0.9080586433410645,0.5868480205535889,0.65633225440979,0.8794941902160645,0.2936332225799561,-0.3300940990447998,-0.5375919342041016,-0.5602662563323975,-0.3236385583877563,0.1526466608047485,0.3272756338119507,0.04533040523529053,-0.5845037698745728,-1.171010613441467,-1.111010670661926,-0.8032658100128174,-0.7042107582092285,-1.126946210861206,-1.220394372940063,-0.6727817058563232,-0.593836784362793,-0.6410447359085083,-0.3347858190536499,-0.4283283948898315,-1.194877982139587,-1.06946325302124,0.3546159267425537,0.6564052104949951,-0.3514562845230103,-0.3259119987487793,0.9266442060470581,1.381734609603882,0.3660099506378174,-1.140459179878235,-1.71001660823822,-0.6585252285003662,0.4523416757583618,0.5445141792297363,0.4071325063705444,0.1484366655349731,-0.1746225357055664,0.4453979730606079,1.267949938774109,1.491985201835632,1.216357111930847,0.3819369077682495,-0.03742432594299316,0.4564497470855713,0.2468554973602295,-0.8833909034729004,-1.522855281829834,-1.757462739944458,-1.754339575767517,-1.37138557434082,-0.7331035137176514,0.4128198623657227,0.8927689790725708,0.4282565116882324,0.658156156539917,1.19032895565033,1.163145303726196,1.256458282470703,1.445294380187988,1.223000407218933,1.721716403961182,2.249049425125122,1.289022445678711,0.194582462310791,0.5229116678237915,1.141466617584229,0.744497537612915,-0.1918691396713257,-1.047934770584106,-1.583637356758118,-1.670956134796143,-1.129576921463013,-0.8710623979568481,-1.436100840568542,-1.829713940620422,-1.643926978111267,-1.440712094306946,-0.8957784175872803,-0.2061159610748291,-1.354924321174622,-2.993710041046143,-2.610064029693604,-1.404834866523743,-0.7386417388916016,-0.1573061943054199,-0.268265962600708,-1.045561552047729,-0.3585705757141113,0.8189095258712769,0.4402062892913818,-0.05700767040252686,0.06579780578613281,-0.08168506622314453,0.3571189641952515,0.9300849437713623,0.4006050825119019,0.02139222621917725,1.033833861351013,2.53374445438385,2.970935940742493,3.211374521255493,4.321048378944397,4.718298554420471,3.949168682098389,3.980035543441772,4.2542484998703,3.016160130500793,2.141636610031128,1.888225793838501,0.6126261949539185,0.5495985746383667,2.361108899116516,2.598874926567078,1.595006704330444,1.458231210708618,0.9813891649246216,0.3951505422592163,0.6097830533981323,1.136844635009766,1.482316374778748,1.454667091369629,1.646226167678833,2.4626305103302,2.110012292861938,0.1751257181167603,-1.297821164131165,-1.804334878921509,-1.873916745185852,-2.030596375465393,-2.057079434394836,-1.439942836761475,-0.6156871318817139,0.08802258968353271,0.3878087997436523,0.1617457866668701,-0.3336464166641235,-0.6896023750305176,-0.7974636554718018,-0.1345299482345581,0.4585322141647339,-0.1146612167358398,-0.6875488758087158,-1.020434617996216,-1.383297801017761,-1.27351176738739,-0.7816214561462402,-0.6132667064666748,-0.281674861907959,0.2659485340118408,0.5007673501968384,0.3183460235595703,-0.4811689853668213,-1.125320792198181,-1.18446671962738,-1.142922520637512,-1.215146899223328,-1.238275051116943,-1.19496488571167,-1.072280645370483,-0.8862544298171997,-0.9704725742340088,-0.8023120164871216,-0.3681095838546753,-0.5800319910049438,-0.9702451229095459,0.04592370986938477,1.421059012413025,0.9610762596130371,-0.4929074048995972,-1.652955293655396,-1.952591300010681,-0.6572978496551514,0.8418509960174561,0.5276066064834595,-0.142498254776001,-0.4722726345062256,-1.304704785346985,-1.677855849266052,-0.9943023920059204,-0.2572356462478638,-0.2150852680206299,-0.5248042345046997,-0.2587687969207764,0.07812845706939697,-0.6592880487442017,-1.7862149477005,-2.50147533416748,-2.388176679611206,-1.535794258117676,-1.374763011932373,-1.664696931838989,-1.400630235671997,-1.691790461540222,-2.435210824012756,-1.659966588020325,-0.04310417175292969,0.6371008157730103,0.7882121801376343,0.715134859085083,0.5332092046737671,0.9359686374664307,0.5470139980316162,-1.165196657180786,-2.393914461135864,-2.873654365539551,-3.172654151916504,-2.241723775863647,-0.320452094078064,0.113133430480957,-1.042902946472168,-1.835918426513672,-0.6187158823013306,1.135428428649902,0.8492045402526855,-0.2772599458694458,-0.6174026727676392,-0.3822705745697021,0.854088306427002,1.858653903007507,1.127086758613586,0.5675243139266968,0.5495942831039429,-0.6253173351287842,-1.214640498161316,-0.02504432201385498,0.8261772394180298,1.008934378623962,1.353240966796875,1.067135095596313,0.5515576601028442,0.618855357170105,0.6410715579986572,0.7284525632858276,1.540148019790649,1.214254260063171,-0.6414985656738281,-1.19056499004364,-0.3219391107559204,0.001812100410461426,-0.5866109132766724,-0.7488770484924316,-0.02237284183502197,0.8127533197402954,1.277027606964111,1.541444063186646,1.745039820671082,1.848997950553894,1.980693340301514,1.819404602050781,1.219604730606079,0.9573673009872437,1.062655806541443,0.8979156017303467,0.9994533061981201,1.677846193313599,1.57480001449585,0.6672585010528564,0.3468589782714844,0.005500674247741699,-1.039743304252625,-1.34871232509613,-0.03824400901794434,0.9732781648635864,0.8441383838653564,1.249486684799194,1.425063014030457,0.0522923469543457,-0.6178994178771973,-0.3352310657501221,-1.032870411872864,-1.420817613601685,-0.3766905069351196,0.6893652677536011,1.1555997133255,1.326009035110474,0.6197447776794434,-0.7205464839935303,-1.539068698883057,-1.62037718296051,-1.574476003646851,-1.522356390953064,-1.045966029167175,-0.4776456356048584,-0.261549711227417,-0.07635605335235596,-0.07531321048736572,-0.1493346691131592,-0.02193188667297363,-0.05773293972015381,-0.171911358833313,0.2025872468948364,0.7019952535629272,0.8631198406219482,0.9044355154037476,0.9938013553619385,0.983751654624939,0.6629573106765747,0.3969572782516479,0.4650231599807739,0.476531982421875,0.21523118019104,0.2342931032180786,0.5229771137237549,0.5478765964508057,0.4421482086181641,0.7327430248260498,1.025028705596924,0.8199781179428101,0.4975851774215698,0.4057753086090088,0.2833442687988281,0.3468718528747559,0.6063272953033447,0.9276741743087769,0.9314979314804077,0.5564092397689819,0.4310867786407471,0.3924243450164795,0.2460315227508545,0.349738597869873,0.7115203142166138,0.7289471626281738,0.3792074918746948,0.4462112188339233,0.7051194906234741,0.6817048788070679,0.7825376987457275,0.8329342603683472,0.7093949317932129,0.6701509952545166,1.385742902755737,1.973096251487732,1.713125824928284,1.264779567718506,1.38368833065033,1.561783790588379,1.038221955299377,1.004282355308533,1.227197527885437,0.8375959396362305,0.5715540647506714,0.6592333316802979,0.5378580093383789,0.7361408472061157,1.091800689697266,1.071911573410034,1.274131894111633,1.615430116653442,1.555190920829773,1.220124006271362,1.069746494293213,1.051798224449158,1.090046525001526,1.31495726108551,1.376623392105103,1.176564931869507,0.9079749584197998,0.4607938528060913,-0.07215034961700439,-0.3321969509124756,-0.2867195606231689,-0.1033787727355957,0.2109600305557251,0.5446043014526367,0.745671272277832,0.8340157270431519,0.6372982263565063,0.2278225421905518,-0.08460652828216553,-0.2964377403259277,-0.5351940393447876,-0.6899875402450562,-0.7274032831192017,-0.8104240894317627,-0.838956356048584,-0.8560473918914795,-0.8743132352828979,-0.7395955324172974,-0.6538506746292114,-0.8899644613265991,-1.271937847137451,-1.435769319534302,-1.143280863761902,-0.4656357765197754,-0.1583232879638672,-0.3137315511703491,-0.35151207447052,-0.2068948745727539,-0.09087002277374268,0.1309196949005127,0.3342633247375488,0.1632499694824219,-0.39870285987854,-0.800254225730896,-0.5656414031982422,-0.3191678524017334,-0.6427237987518311,-0.9242699146270752,-0.8899698257446289,-1.189828991889954,-1.62373423576355,-1.220199108123779,-0.9928743839263916,-1.575872898101807,-1.461676239967346,-1.051735997200012,-1.298141956329346,-1.103501558303833,-1.112186551094055,-2.014807820320129,-1.880829334259033,-1.050030112266541,-0.96959388256073,-0.7251577377319336,-0.4431020021438599,-1.111376523971558,-1.419329524040222,-1.120882272720337,-1.346471071243286,-1.586282014846802,-1.142308831214905,-0.6395866870880127,-0.5189645290374756,-0.544947624206543,-0.6966694593429565,-1.10367214679718,-1.454943895339966,-1.062090396881104,-0.3582980632781982,-0.2399332523345947,-0.3594739437103271,-0.1756922006607056,-0.2098699808120728,-0.5301525592803955,-0.4460180997848511,-0.1937606334686279,-0.3771786689758301,-0.530864953994751,-0.2572184801101685,-0.1053067445755005,-0.3202825784683228,-0.3537383079528809,-0.08246290683746338,0.1093236207962036,0.1949150562286377,0.2893663644790649,0.2831339836120605,0.2172085046768188,0.3066902160644531,0.5545756816864014,0.871964693069458,0.9946532249450684,1.110574007034302,1.312214970588684,0.9770439863204956,0.3921400308609009,0.3155232667922974,0.4047678709030151,0.3251738548278809,0.469041109085083,0.9824588298797607,1.422971963882446,1.249087572097778,0.9897555112838745,1.156704783439636,1.006927013397217,0.3617538213729858,0.1205556392669678,0.5591332912445068,0.8579345941543579,1.196246981620789,1.78149425983429,1.706912755966187,0.9027478694915771,0.4925640821456909,0.5020859241485596,0.4319525957107544,0.6915668249130249,0.9063806533813477,1.061773896217346,1.489220380783081,1.73614239692688,1.54358446598053,0.9075930118560791,-0.5369374752044678,-1.216975092887878,-0.0617058277130127,0.9748831987380981,1.016149520874023,1.176511287689209,1.776819705963135,2.070199728012085,1.743785619735718,1.21198296546936,0.8867404460906982,0.9246304035186768,1.131814956665039,1.289202690124512,1.253580808639526,1.118744015693665,1.281191468238831,1.329127907752991,0.6685856580734253,-0.2937523126602173,-0.9181748628616333,-1.254186987876892,-1.374301671981812,-1.223807215690613,-0.9107612371444702,-0.5811939239501953,-0.3556770086288452,-0.3156520128250122,-0.3816697597503662,-0.5484205484390259,-0.8905191421508789,-1.12510621547699,-0.7987790107727051,-0.3527276515960693,-0.4181660413742065,-0.3531385660171509,0.1875100135803223,0.2042362689971924,-0.1939548254013062,-0.1697613000869751,-0.08758378028869629,-0.28938889503479,-0.4237278699874878,-0.2903437614440918,-0.05238568782806396,0.08395528793334961,0.214508056640625,0.3907710313796997,0.5289691686630249,0.5292609930038452,0.4270591735839844,0.1707816123962402,-0.1422214508056641,-0.2186965942382812,-0.1168348789215088,-0.06615829467773438,-0.0813138484954834,0.1921073198318481,0.6694900989532471,0.7800893783569336,0.5350652933120728,0.2079581022262573,-0.07640969753265381,-0.07873678207397461,0.3304792642593384,0.6719502210617065,0.5499815940856934,0.2337545156478882,0.1440078020095825,0.3054124116897583,0.3391824960708618,0.006118655204772949,-0.162473201751709,0.2183672189712524,0.5274574756622314,0.4661872386932373,0.4162005186080933,0.183771014213562,-0.24993896484375,-0.3087608814239502,-0.1212723255157471,-0.08509790897369385,0.04607069492340088,0.4379242658615112,0.7311916351318359,0.6552067995071411,0.223847508430481,-0.2108774185180664,-0.2653369903564453,-0.09111893177032471,0.1403117179870605,0.4450492858886719,0.5836004018783569,0.5243868827819824,0.5039291381835938,0.4624514579772949,0.1489055156707764,-0.1221413612365723,0.1178004741668701,0.5110702514648438,0.5307973623275757,0.3451606035232544,0.3469759225845337,0.4217730760574341,0.3572530746459961,0.1825307607650757,0.06013619899749756,0.08690893650054932,0.2189744710922241,0.4650027751922607,0.7098551988601685,0.5764743089675903,0.0473935604095459,-0.1607834100723267,-0.03347611427307129,0.214607834815979,0.703274130821228,0.878008246421814,0.5737674236297607,0.3133399486541748,0.1346136331558228,0.04021275043487549,0.2361577749252319,0.2797157764434814,0.1138865947723389,0.1744787693023682,0.04469633102416992,-0.3957202434539795,-0.3992081880569458,-0.1111292839050293,-0.2315475940704346,-0.4036542177200317,-0.2112658023834229,-0.01010441780090332,0.09911835193634033,0.1944944858551025,-0.0006372928619384766,-0.2962210178375244,-0.1419092416763306,0.6345945596694946,1.482897877693176,1.899462103843689,1.681445717811584,1.107922911643982,0.6296743154525757,0.3228564262390137,0.420052170753479,0.7019115686416626,0.7022806406021118,0.6385663747787476,0.8588154315948486,0.7950646877288818,0.06526458263397217,-0.4547138214111328,-0.294608473777771,-0.2536822557449341,-0.3968628644943237,-0.1738028526306152,-0.05834877490997314,-0.174059271812439,0.02880048751831055,0.3780004978179932,0.4244606494903564,0.1340932846069336,-0.1801468133926392,-0.2702046632766724,-0.2353756427764893,-0.1781255006790161,-0.07554066181182861,0.09788990020751953,0.2968229055404663,0.4718252420425415,0.5595871210098267,0.4011576175689697,0.1603628396987915,0.1873126029968262,0.2980567216873169,0.2746313810348511,0.2107293605804443,0.1266775131225586,-0.02759134769439697,-0.1757147312164307,0.09334945678710938,0.7405718564987183,0.8656550645828247,0.2535921335220337,-0.4592767953872681,-0.7937386035919189,-0.8653192520141602,-0.8443969488143921,-0.3790433406829834,0.3471454381942749,0.6757686138153076,0.5922768115997314,0.5854350328445435,0.7638566493988037,0.7101502418518066,0.4362527132034302,0.2336536645889282,-0.008225798606872559,-0.07027387619018555,0.3301960229873657,0.8835411071777344,0.9649761915206909,0.5959771871566772,0.1802444458007812,-0.2625925540924072,-0.7457517385482788,-1.117836356163025,-1.170210242271423,-0.9217582941055298,-0.6382230520248413,-0.4128799438476562,-0.2297365665435791,-0.1234159469604492,-0.04821431636810303,0.1233043670654297,0.2711530923843384,0.5708416700363159,0.8860141038894653,0.5724402666091919,-0.07460832595825195,-0.2934411764144897,-0.1050631999969482,-0.009361982345581055,0.1217626333236694,0.1822947263717651,-0.2169381380081177,-0.4938429594039917,-0.2259331941604614,-0.1120562553405762,-0.2091790437698364,-0.1111936569213867,-0.1118019819259644,-0.3419280052185059,-0.4663567543029785,-0.349590539932251,-0.2906548976898193,-0.5541304349899292,-0.6258301734924316,-0.1241605281829834,0.1845349073410034,0.1833633184432983,0.3222910165786743,0.4673609733581543,0.3869097232818604,0.4807612895965576,0.7558701038360596,0.6339733600616455,0.1305012702941895,-0.07517266273498535,0.2964431047439575,0.4883583784103394,0.1397398710250854,-0.2784272432327271,-0.2887258529663086,-0.1092528104782104,-0.0685347318649292,-0.06160819530487061,-0.0989069938659668,-0.1379181146621704,-0.1274220943450928,-0.06543087959289551,-0.009522914886474609,-0.3266007900238037,-0.6519355773925781,-0.42072594165802,-0.02702057361602783,0.181749701499939,0.2966469526290894,0.3391299247741699,0.2589340209960938,0.01238000392913818,-0.1359955072402954,-0.1767758131027222,-0.343672513961792,-0.4536452293395996,-0.1668816804885864,0.004142403602600098,-0.01667797565460205,0.141848087310791,0.09417557716369629,-0.3801548480987549,-0.8018635511398315,-0.7810710668563843,-0.4189503192901611,0.1090596914291382,0.4873327016830444,0.7869719266891479,1.028876066207886,0.7167731523513794,0.2412818670272827,0.3298280239105225,0.4711503982543945,0.06099772453308105,-0.4710334539413452,-0.7369143962860107,-0.6407679319381714,-0.1660737991333008,0.09663248062133789,0.1278480291366577,0.1432074308395386,-0.03939521312713623,-0.335982084274292,-0.3265568017959595,-0.02882194519042969,0.2221008539199829,0.6396971940994263,1.014558434486389,0.8239327669143677,0.3858261108398438,0.1695917844772339,0.01940417289733887,-0.1410906314849854,-0.2838517427444458,-0.5194591283798218,-0.6974762678146362,-0.7681642770767212,-0.684224009513855,-0.2130800485610962,0.1719038486480713,0.08766853809356689,0.2691693305969238,0.6131690740585327,0.4425913095474243,0.1015967130661011,-0.0432811975479126,-0.03801333904266357,0.1939151287078857,0.7337204217910767,1.231449365615845,1.29054594039917,0.8774557113647461,0.2989386320114136,-0.3022785186767578,-0.837483286857605,-0.8198150396347046,-0.05307555198669434,0.7039865255355835,0.6704020500183105,0.482649564743042,0.6054636240005493,0.4823566675186157,0.01375973224639893,-0.1320419311523438,0.1191920042037964,0.2993592023849487,0.3533488512039185,0.515534520149231,0.7328567504882812,0.5620783567428589,0.1679760217666626,0.1464024782180786,0.2702443599700928,0.1624828577041626,-0.000101923942565918,-0.02025496959686279,-0.00798332691192627,-0.1175258159637451,-0.2337373495101929,-0.2010540962219238,-0.1283329725265503,-0.04773366451263428,0.161125659942627,0.2706949710845947,0.2278257608413696,0.1709940433502197,0.145318865776062,0.08936154842376709,0.07884728908538818,0.2070826292037964,0.3699259757995605,0.4425323009490967,0.2340645790100098,0.2614295482635498,0.5951961278915405,0.6012568473815918,0.3420288562774658,0.4692513942718506,0.5978364944458008,0.2203327417373657,0.1876645088195801,0.5972464084625244,0.5706045627593994,0.4273338317871094,0.7715953588485718,0.8396065235137939,0.2982627153396606,0.1242045164108276,0.460726261138916,0.2236082553863525,-0.3092114925384521,-0.220400333404541,-0.0284346342086792,-0.1414564847946167,-0.1293522119522095,0.1123673915863037,0.08129024505615234,-0.1112955808639526,-0.04764997959136963,0.1609314680099487,0.0741276741027832,-0.2793756723403931,-0.2235792875289917,0.180077075958252,0.2644593715667725,0.2067210674285889,0.3371869325637817,0.4337722063064575,0.2385503053665161,-0.1145796775817871,-0.3873163461685181,-0.2070515155792236,0.06590723991394043,0.2297236919403076,0.5761417150497437,0.460500955581665,-0.2956255674362183,-0.715434193611145,-0.3374208211898804,0.1760237216949463,0.4745246171951294,0.6642780303955078,0.7579493522644043,0.8500907421112061,0.7420127391815186,0.4007230997085571,0.1483175754547119,0.06732666492462158,-0.1073076725006104,-0.1457823514938354,0.1223409175872803,0.4290440082550049,0.3693101406097412,0.06754875183105469,-0.05579102039337158,0.1169582605361938,0.2618190050125122,0.1868319511413574,0.1707344055175781,0.02738642692565918,-0.3979872465133667,-0.5588994026184082,-0.1541004180908203,0.1801275014877319,0.03316712379455566,-0.3075302839279175,-0.5385875701904297,-0.5182886123657227,-0.243146538734436,0.375906229019165,0.932939887046814,0.8337228298187256,0.5258556604385376,0.4570891857147217,0.3638448715209961,0.04999101161956787,-0.05831122398376465,0.1377303600311279,0.3568786382675171,0.2817102670669556,-0.1342778205871582,-0.6222671270370483,-1.09794294834137,-1.167069911956787,-0.7562263011932373,-0.1957540512084961,0.05829191207885742,-0.2522917985916138,-0.5158295631408691,-0.2851585149765015,0.1302362680435181,0.245171070098877,-0.03986620903015137,-0.3205068111419678,-0.2278107404708862,0.04016339778900146,0.4098125696182251,0.701876163482666,0.4070219993591309,-0.03590297698974609,0.0006780624389648438,0.135205864906311,-0.1834534406661987,-0.3952621221542358,-0.2424137592315674,0.06202661991119385,0.3942579030990601,0.4184246063232422,0.09099662303924561,-0.3802074193954468,-0.7376804351806641,-0.9260498285293579,-0.8393168449401855,-0.1129671335220337,0.754984974861145,0.9705519676208496,0.7766507863998413,0.3666118383407593,-0.01880550384521484,0.09022951126098633,0.4492850303649902,0.2945172786712646,-0.1025891304016113,-0.254284143447876,-0.4671345949172974,-0.5409296751022339,-0.05999994277954102,0.5666606426239014,0.3703830242156982,-0.2678142786026001,-0.339677095413208,-0.3761025667190552,-0.7605350017547607,-0.6842637062072754,-0.2317814826965332,0.05812561511993408,0.3791141510009766,0.536906361579895,0.1099984645843506,-0.3946763277053833,-0.4386334419250488,-0.3582165241241455,-0.4527536630630493,-0.6444286108016968,-0.8506808280944824,-0.9393085241317749,-0.7489467859268188,-0.1968580484390259,0.5279166698455811,0.8284925222396851,0.4616854190826416,0.2044111490249634,0.4022412300109863,0.3670763969421387,0.2375965118408203,0.5882599353790283,0.9695402383804321,0.95905601978302,0.6856187582015991,0.5344247817993164,0.477831244468689,0.04223513603210449,-0.5161482095718384,-0.58442223072052,-0.3885469436645508,-0.4505939483642578,-0.5625976324081421,-0.3993991613388062,-0.2711606025695801,-0.3618686199188232,-0.5279520750045776,-0.880829930305481,-1.437135100364685,-1.585361480712891,-1.135595798492432,-0.629990816116333,0.04858660697937012,0.6111477613449097,0.6440767049789429,0.5067658424377441,0.2664409875869751,-0.1287556886672974,-0.5457243919372559,-0.6053402423858643,-0.1911921501159668,0.503822922706604,1.086769938468933,1.439029812812805,1.501936197280884,1.09098744392395,0.08244466781616211,-0.6367939710617065,-0.4952859878540039,-0.5142481327056885,-0.680403470993042,-0.2566283941268921,0.3591617345809937,0.5407569408416748,0.1570358276367188,-0.2368487119674683,-0.2876937389373779,-0.312635064125061,-0.3334693908691406,-0.05043411254882812,0.4258135557174683,0.6561434268951416,0.6040463447570801,0.3262789249420166,-0.07755124568939209,-0.2262818813323975,-0.2146614789962769,-0.3998755216598511,-0.5725743770599365,-0.4879732131958008,-0.5855444669723511,-0.9440839290618896,-1.009013772010803,-0.9637531042098999,-1.004678249359131,-0.9467393159866333,-0.6364806890487671,0.05620944499969482,0.7090730667114258,0.8105957508087158,0.4901522397994995,0.2903416156768799,0.1569113731384277,-0.1626030206680298,-0.3342000246047974,-0.1878458261489868,-0.08279228210449219,-0.06704342365264893,0.09336447715759277,0.2087541818618774,0.293184757232666,0.2362232208251953,0.1377003192901611,0.5684244632720947,1.137207269668579,1.00264835357666,0.6695898771286011,0.4925930500030518,0.3488588333129883,0.0881878137588501,-0.2594565153121948,-0.6805729866027832,-1.08629035949707,-0.9647390842437744,-0.1594830751419067,0.5642702579498291,0.42637038230896,-0.3624275922775269,-1.012722730636597,-1.263525366783142,-1.439177870750427,-1.541020274162292,-1.154155611991882,-0.3730394840240479,0.3219702243804932,0.9223151206970215,1.125466704368591,0.811640739440918,0.6279909610748291,0.6963046789169312,0.3446649312973022,-0.06560039520263672,-0.1371220350265503,-0.4206948280334473,-0.5676037073135376,0.04870033264160156,0.6437205076217651,0.3552746772766113,0.01499569416046143,-0.05268824100494385,-0.3593366146087646,-0.4880611896514893,-0.3749653100967407,-0.15770423412323,0.1663377285003662,0.4203826189041138,0.5259307622909546,0.1977120637893677,-0.1600549221038818,-0.2563730478286743,-0.3539206981658936,-0.29503333568573,-0.07498598098754883,-0.3382694721221924,-0.7582100629806519,-0.8863906860351562,-0.8292049169540405,-0.4370981454849243,-0.02190399169921875,0.01157534122467041,-0.02138900756835938,-0.1492735147476196,-0.8207441568374634,-1.364771246910095,-1.270755529403687,-0.6462106704711914,0.1308757066726685,0.421301007270813,0.2132935523986816,0.02155852317810059,-0.1440689563751221,-0.4486348628997803,-0.3695815801620483,0.03281843662261963,0.2737408876419067,0.280800461769104,-0.02473211288452148,-0.1884777545928955,0.08067119121551514,0.2051321268081665,0.1092431545257568,0.43390953540802,0.6342898607254028,0.1398471593856812,-0.2082563638687134,-0.03725910186767578,0.2064721584320068,0.06985223293304443,-0.379576563835144,-0.5480815172195435,-0.4922508001327515,-0.5925589799880981,-0.629092812538147,-0.5336533784866333,-0.5134016275405884,-0.5645277500152588,-0.4148905277252197,-0.1673966646194458,-0.1864993572235107,-0.5887845754623413,-0.8277372121810913,-0.7730072736740112,-0.5455881357192993,0.01688611507415771,0.7859988212585449,0.8568005561828613,-0.112984299659729,-0.8144077062606812,-0.602899432182312,-0.1229116916656494,0.4459333419799805,1.141273498535156,1.467561006546021,1.288904428482056,0.8456028699874878,0.290837287902832,-0.339552640914917,-0.6870864629745483,-0.4266740083694458,-0.03400075435638428,0.1507326364517212,0.2473404407501221,0.1405230760574341,0.05895495414733887,0.3264323472976685,0.3395301103591919,-0.2311785221099854,-0.8455438613891602,-1.010860204696655,-0.8901329040527344,-0.7465757131576538,-0.4770673513412476,-0.02174520492553711,0.3319834470748901,0.5076627731323242,0.5972528457641602,0.646371603012085,0.4212419986724854,-0.07110428810119629,-0.4064716100692749,-0.414832592010498,-0.4124304056167603,-0.476207971572876,-0.4205349683761597,-0.2294919490814209,0.07085752487182617,0.08066582679748535,-0.0732414722442627,-0.136056661605835,-0.07939445972442627,-0.07658135890960693,-0.1398589611053467,0.2139351367950439,0.8617615699768066,1.177047729492188,1.342244982719421,1.631301283836365,1.279335379600525,0.05124306678771973,-0.9312050342559814,-0.7867476940155029,-0.3790326118469238,-0.5967421531677246,-0.3732240200042725,0.3101416826248169,0.1402376890182495,-0.3172109127044678,-0.4180651903152466,-0.6886593103408813,-0.9706206321716309,-0.5490202903747559,0.1785986423492432,0.3097565174102783,-0.3690215349197388,-0.7559806108474731,-0.2287774085998535,0.1082711219787598,-0.04472637176513672,0.1298060417175293,0.6039100885391235,0.6884908676147461,0.4269894361495972,0.3035863637924194,0.03226375579833984,-0.2689729928970337,-0.01429188251495361,0.2933306694030762,0.001357197761535645,-0.4549520015716553,-0.4174396991729736,0.04200553894042969,0.2025110721588135,0.08510005474090576,-0.0458979606628418,-0.2474852800369263,-0.3207610845565796,-0.477357029914856,-0.7789843082427979,-0.7314115762710571,-0.4850506782531738,-0.2383818626403809,-0.1518462896347046,-0.4419057369232178,-0.5480471849441528,-0.1894272565841675,-0.1092238426208496,-0.08879077434539795,-0.03172731399536133,-0.4119658470153809,-0.8040962219238281,-0.6007161140441895,0.03996706008911133,0.317878246307373,0.1014357805252075,-0.04398715496063232,0.04309344291687012,0.02373433113098145,-0.1072754859924316,-0.1579606533050537,0.3581714630126953,0.4838308095932007,0.1705348491668701,0.5887995958328247,0.8091537952423096,0.04615545272827148,-0.8911242485046387,-0.9733768701553345,-0.4845485687255859,-0.1461235284805298,0.177379846572876,0.8510777950286865,1.233650922775269,1.034963607788086,0.8866664171218872,1.013670086860657,0.8468195199966431,-0.1074879169464111,-1.013905048370361,-0.9785556793212891,-0.5891493558883667,-0.3721457719802856,-0.3365753889083862,-0.5881537199020386,-1.22397243976593,-1.504005789756775,-1.337915897369385,-1.227702856063843,-0.7506011724472046,-0.2964677810668945,-0.3810313940048218,-0.5065673589706421,-0.340801477432251,-0.2080557346343994,0.1999329328536987,0.8182861804962158,1.075626969337463,0.6886206865310669,-0.2064635753631592,-0.7336657047271729,-0.3846631050109863,0.03113186359405518,-0.04050564765930176,0.3775337934494019,1.018021702766418,0.4208718538284302,-0.6867678165435791,-0.4917529821395874,0.4682235717773438,0.4734174013137817,-0.3181003332138062,-0.5736322402954102,-0.4122061729431152,-0.8397256135940552,-0.8746093511581421,-0.06382155418395996,0.2085803747177124,-0.2843431234359741,-0.186069130897522,0.6864116191864014,0.5438597202301025,0.05483508110046387,0.6166141033172607,0.9335868358612061,0.2426766157150269,-0.3793405294418335,-0.5518172979354858,-0.8364962339401245,-1.057954430580139,-1.046903729438782,-1.03511381149292,-1.235564947128296,-1.41858172416687,-0.8559669256210327,0.1153489351272583,0.1800169944763184,-0.396481990814209,-0.4329836368560791,-0.1917983293533325,-0.3595994710922241,-0.3605124950408936,-0.1019303798675537,-0.05400896072387695,-0.3764383792877197,-0.6634615659713745,-0.4274851083755493,0.1630568504333496,0.5370801687240601,0.3287969827651978,-0.1285711526870728,-0.4793665409088135,-0.783899188041687,-0.9548631906509399,-0.5048196315765381,0.1685822010040283,0.3723024129867554,0.6971629858016968,0.7552617788314819,0.3180896043777466,0.06944990158081055,-0.01503109931945801,0.1208345890045166,0.2441797256469727,0.1801457405090332,0.208765983581543,0.2241758108139038,0.06908512115478516,-0.04211711883544922,-0.2486032247543335,-0.7628331184387207,-0.6029262542724609,-0.008998274803161621,-0.6332781314849854,-1.563593745231628,-1.184841156005859,-0.423998236656189,-0.7618256807327271,-1.267855525016785,-0.8061883449554443,-0.7629543542861938,-1.12943422794342,-0.736932635307312,-0.1040782928466797,0.2669699192047119,0.3744975328445435,0.4700045585632324,0.6132742166519165,0.3166047334671021,-0.09019732475280762,0.3238617181777954,0.7784038782119751,0.4112094640731812,-0.1030333042144775,-0.5633786916732788,-1.33487856388092,-1.833232998847961,-1.081865787506104,0.6610937118530273,1.94522488117218,1.60511326789856,1.008810997009277,0.480627179145813,-0.54936683177948,-0.933239221572876,-0.1208184957504272,0.7400450706481934,0.7706501483917236,0.7045540809631348,0.1908423900604248,-0.9360920190811157,-1.939366936683655,-2.281144738197327,-1.554202795028687,-0.8082633018493652,-0.9534566402435303,-0.7988401651382446,-0.2878847122192383,-0.2158716917037964,-0.4295257329940796,-0.4454258680343628,-0.1201983690261841,-0.5256335735321045,-0.8508932590484619,-0.2348842620849609,0.5941758155822754,1.50811493396759,2.17218804359436,1.591598153114319,0.4258929491043091,0.02799046039581299,-0.1948753595352173,-0.7385365962982178,-0.8860419988632202,-0.1763616800308228,0.5231004953384399,0.5122064352035522,0.3820356130599976,0.2825782299041748,-0.4049406051635742,-1.311095952987671,-1.378321766853333,-0.7212792634963989,-0.009554028511047363,0.272486686706543,-0.1810941696166992,-0.5870518684387207,-0.7013289928436279,-0.85918128490448,-0.6378647089004517,0.02342641353607178,0.05747652053833008,-0.2208616733551025,0.1448993682861328,0.5458821058273315,0.5604196786880493,0.2423933744430542,0.2150058746337891,0.1625697612762451,-0.1690714359283447,0.2249847650527954,1.219541430473328,1.343227744102478,-0.1409822702407837,-1.775669574737549,-2.083035707473755,-1.954641580581665,-2.060097455978394,-1.588317275047302,-0.9862407445907593,-0.3907710313796997,0.9866269826889038,2.18837571144104,1.170715570449829,-0.2854492664337158,0.0450439453125,0.3777987957000732,0.2403473854064941,0.2856906652450562,0.213310718536377,-0.07184886932373047,0.1532560586929321,0.9231412410736084,1.13688862323761,0.2711327075958252,-0.8227944374084473,-0.8142532110214233,-0.2431637048721313,-0.1713963747024536,-0.6735638380050659,-0.7199360132217407,-0.1117043495178223,0.3643609285354614,0.4005235433578491,-0.03479576110839844,-0.4265538454055786,-0.2570521831512451,-0.07629704475402832,-0.1502487659454346,0.06200838088989258,0.3666976690292358,0.5605806112289429,0.5098686218261719,-0.002731561660766602,-0.5372110605239868,-0.5091047286987305,0.03435158729553223,0.4112566709518433,0.3960345983505249,-0.01504397392272949,-0.8375551700592041,-1.286224365234375,-0.6200838088989258,0.08684992790222168,0.05664074420928955,0.3789832592010498,0.8881856203079224,0.5333529710769653,-0.3885802030563354,-0.7143012285232544,-1.011428833007812,-1.662806510925293,-1.493422865867615,-0.5224320888519287,-0.08400893211364746,-0.6446624994277954,-1.180278182029724,-0.7943383455276489,0.06021344661712646,-0.01652348041534424,-0.271910548210144,0.01860809326171875,0.09876000881195068,0.6236618757247925,1.443645358085632,1.276191830635071,0.3515431880950928,-0.4498171806335449,-0.8762143850326538,-0.7514519691467285,-0.5378333330154419,-0.3257886171340942,-0.2576626539230347,-0.3188610076904297,-0.1849511861801147,-0.322124719619751,-0.3780691623687744,-0.4164472818374634,-0.4730247259140015,-0.2445434331893921,0.3551180362701416,0.9826347827911377,1.537488341331482,1.959212064743042,1.284122586250305,-0.0630415678024292,-0.8072676658630371,-1.026752829551697,-1.105973482131958,-1.129516839981079,-1.141169428825378,-0.949219822883606,-0.558404803276062,-0.4446501731872559,-0.6187255382537842,-1.051123380661011,-1.936810255050659,-2.382521510124207,-1.643799304962158,-0.5119113922119141,0.2692959308624268,0.8694498538970947,0.8127983808517456,0.3803147077560425,0.1219267845153809,-0.3230774402618408,-1.182429313659668,-1.933312654495239,-1.469586610794067,-0.09833621978759766,0.8850506544113159,1.349869966506958,1.683888673782349,1.925749897956848,1.456029653549194,0.4814951419830322,0.3785895109176636,0.3216977119445801,-0.4697384834289551,-0.4436255693435669,0.2393946647644043,0.07740318775177002,-0.3552221059799194,-0.07232630252838135,0.149714469909668,-0.3452035188674927,-0.9308434724807739,-1.073367476463318,-1.405972123146057,-1.896171569824219,-1.418]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"fft filter output"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"threshold"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"direct audio"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
