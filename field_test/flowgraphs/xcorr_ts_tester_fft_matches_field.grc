<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xcorr_tester</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_mic_offset</value></param>
<param><key>value</key><value>1024*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d2</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d3</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mic_distance</value></param>
<param><key>value</key><value>.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>astra_xcorr_ts_ff</key>
<param><key>id</key><value>astra_xcorr_ts_ff_0</value></param>
<param><key>ip_address</key><value>127.0.0.1</value></param>
<param><key>center_mic_offset</key><value>center_mic_offset</value></param>
<param><key>mic_distance</key><value>mic_distance</value></param>
<param><key>node_number</key><value>1</value></param>
<param><key>port_num</key><value>5556</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_window</key><value>15000</value></param>
<param><key>test_number</key><value>AK47.130m.90deg.shot2</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>plughw:2,0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>d2+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>d3+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>delay</key><value>d1+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ben/Desktop/senior_design/field_test/audio_recordings/ar15</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>10</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>10</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0.2577400207519531,0.2350366115570068,0.2213370800018311,0.187675952911377,0.1846396923065186,0.2139890193939209,0.2186059951782227,0.2017295360565186,0.2149724960327148,0.2432453632354736,0.2678549289703369,0.2732276916503906,0.1983273029327393,0.09502172470092773,0.008687973022460938,-0.0908505916595459,-0.1806628704071045,-0.1921713352203369,-0.1279497146606445,-0.05277395248413086,-0.02495050430297852,-0.04661679267883301,-0.07308363914489746,-0.07387876510620117,-0.07821202278137207,-0.09140253067016602,-0.08205413818359375,-0.1264798641204834,-0.2375388145446777,-0.3306841850280762,-0.4335236549377441,-0.5248343944549561,-0.559927225112915,-0.5911850929260254,-0.6096756458282471,-0.6138229370117188,-0.63773512840271,-0.6872797012329102,-0.7454514503479004,-0.8250737190246582,-0.8872091770172119,-0.8987486362457275,-0.9171938896179199,-0.954737663269043,-0.9776246547698975,-0.9636092185974121,-0.9466171264648438,-0.9625792503356934,-0.9845089912414551,-0.9578549861907959,-0.8892643451690674,-0.8055651187896729,-0.7713103294372559,-0.7781779766082764,-0.7991671562194824,-0.8368015289306641,-0.8617377281188965,-0.864027738571167,-0.8548712730407715,-0.8778750896453857,-0.9260201454162598,-0.9468579292297363,-0.9637486934661865,-0.9692215919494629,-0.9133219718933105,-0.8155977725982666,-0.7910740375518799,-0.839533805847168,-0.8435308933258057,-0.8018028736114502,-0.8179128170013428,-0.8627486228942871,-0.9404182434082031,-1.037039756774902,-1.067386865615845,-1.019856929779053,-0.9343087673187256,-0.8483564853668213,-0.7690107822418213,-0.6819474697113037,-0.6044685840606689,-0.5975425243377686,-0.6304752826690674,-0.6440639495849609,-0.649343729019165,-0.6464731693267822,-0.6819534301757812,-0.7825875282287598,-0.8842742443084717,-0.92842698097229,-0.9350907802581787,-0.8873999118804932,-0.7974493503570557,-0.6895685195922852,-0.5621254444122314,-0.4399585723876953,-0.3447306156158447,-0.3207790851593018,-0.3320825099945068,-0.2810883522033691,-0.2168488502502441,-0.1609575748443604,-0.1151621341705322,-0.1238870620727539,-0.1583993434906006,-0.1743602752685547,-0.1753997802734375,-0.206151008605957,-0.199730396270752,-0.09414792060852051,0.04207849502563477,0.09286403656005859,-0.0224459171295166,-0.1385939121246338,-0.1234710216522217,-0.1091480255126953,-0.1588833332061768,-0.1789176464080811,-0.185089111328125,-0.09016871452331543,0.09609341621398926,0.1632905006408691,0.06968021392822266,-0.0387108325958252,-0.08614778518676758,-0.05202293395996094,0.05271196365356445,0.1312220096588135,0.1687192916870117,0.1430284976959229,0.09600400924682617,0.1381182670593262,0.2620720863342285,0.3585159778594971,0.4075944423675537,0.4968929290771484,0.6124603748321533,0.6410336494445801,0.5631077289581299,0.4035413265228271,0.2600491046905518,0.185621976852417,0.1472234725952148,0.2046644687652588,0.286332368850708,0.2704203128814697,0.1653563976287842,0.03401994705200195,-0.03931879997253418,-0.03957509994506836,0.005261898040771484,0.1057195663452148,0.2114403247833252,0.28708815574646,0.2671670913696289,0.125114917755127,-0.05548954010009766,-0.2021121978759766,-0.2975142002105713,-0.3487110137939453,-0.3458809852600098,-0.3360509872436523,-0.4090976715087891,-0.5323529243469238,-0.5992889404296875,-0.5703556537628174,-0.5464684963226318,-0.5204164981842041,-0.5213356018066406,-0.6240379810333252,-0.6523501873016357,-0.5663955211639404,-0.5152690410614014,-0.4962372779846191,-0.4728376865386963,-0.4636287689208984,-0.414118766784668,-0.3990602493286133,-0.4126965999603271,-0.3574776649475098,-0.3462362289428711,-0.3685832023620605,-0.2975845336914062,-0.2122747898101807,-0.1515650749206543,-0.08085012435913086,-0.03649592399597168,-0.09634733200073242,-0.1697242259979248,-0.2471625804901123,-0.3988504409790039,-0.6180763244628906,-0.8864295482635498,-0.9738564491271973,-0.8340227603912354,-0.6720352172851562,-0.5784690380096436,-0.6677210330963135,-0.905299186706543,-1.068630218505859,-0.9783494472503662,-0.8068430423736572,-0.5750870704650879,-0.3161132335662842,-0.3453743457794189,-0.509716272354126,-0.6152856349945068,-0.7627713680267334,-0.843818187713623,-0.8292853832244873,-0.8843863010406494,-0.8915925025939941,-0.7875454425811768,-0.7781243324279785,-0.7979047298431396,-0.6722211837768555,-0.5283665657043457,-0.5147349834442139,-0.5799174308776855,-0.6486928462982178,-0.6900489330291748,-0.6467640399932861,-0.5634331703186035,-0.507427453994751,-0.4069387912750244,-0.331878662109375,-0.4054772853851318,-0.491187572479248,-0.5752599239349365,-0.6305027008056641,-0.3978610038757324,-0.07514357566833496,-0.04668712615966797,0.033416748046875,0.1918923854827881,0.01466751098632812,-0.2241337299346924,-0.1495027542114258,0.1332640647888184,0.3743565082550049,0.6044137477874756,0.7784020900726318,0.7463359832763672,0.6120097637176514,0.4874253273010254,0.6094622611999512,0.9475505352020264,1.136473417282104,1.147054433822632,1.163220405578613,1.081633567810059,0.8414912223815918,0.7386660575866699,0.8061254024505615,0.9502017498016357,1.179517507553101,1.213045120239258,1.074895858764648,1.044094562530518,0.7918095588684082,0.5267775058746338,0.5834841728210449,0.482637882232666,0.3080976009368896,0.4488706588745117,0.6544172763824463,0.8660054206848145,1.181008815765381,1.278197765350342,1.328269243240356,1.524295806884766,1.501549482345581,1.459404230117798,1.55158519744873,1.21267557144165,0.6701409816741943,0.400090217590332,0.08718132972717285,-0.1953184604644775,-0.06609559059143066,0.1964807510375977,0.35530686378479,0.545579195022583,0.6561851501464844,0.5671417713165283,0.3404140472412109,-0.08809566497802734,-0.4521059989929199,-0.5845499038696289,-0.60813307762146,-0.5206012725830078,-0.4673397541046143,-0.3897297382354736,-0.1930630207061768,-0.07792234420776367,-0.06031274795532227,-0.04006028175354004,-0.1740181446075439,-0.4662787914276123,-0.77553391456604,-1.060948371887207,-1.309834718704224,-1.496493816375732,-1.440334320068359,-1.149718761444092,-0.7566773891448975,-0.2752768993377686,0.08278131484985352,0.1601302623748779,0.2194523811340332,0.3272664546966553,0.2176988124847412,0.0769495964050293,0.2110052108764648,0.2986347675323486,-0.069122314453125,-0.645136833190918,-0.9159600734710693,-0.7610392570495605,-0.4522788524627686,-0.2916848659515381,-0.322643518447876,-0.5196690559387207,-0.7688295841217041,-0.7815563678741455,-0.6114363670349121,-0.5914294719696045,-0.6329357624053955,-0.5699384212493896,-0.4893648624420166,-0.4390048980712891,-0.3600764274597168,-0.2507364749908447,-0.1389336585998535,0.003741979598999023,0.263056755065918,0.6945323944091797,1.111085414886475,1.382769346237183,1.37475848197937,1.029527187347412,0.4955136775970459,-0.191885232925415,-0.6808245182037354,-0.5602478981018066,-0.05994558334350586,0.1417601108551025,-0.1310455799102783,-0.2574074268341064,-0.05102992057800293,0.2576863765716553,0.4374957084655762,0.346071720123291,0.2347934246063232,-0.001305341720581055,-0.5471158027648926,-1.000130176544189,-1.179457902908325,-1.156145334243774,-0.8924019336700439,-0.6118488311767578,-0.4606389999389648,-0.3140532970428467,-0.02483725547790527,0.429617166519165,0.845644474029541,0.7184982299804688,0.1721978187561035,-0.3559815883636475,-0.8225893974304199,-0.8749186992645264,-0.3861665725708008,0.1093244552612305,0.5595219135284424,1.046171188354492,1.25622034072876,1.338748931884766,1.305124759674072,1.062799692153931,0.8899807929992676,0.8201098442077637,0.4622578620910645,0.02506136894226074,-0.08145809173583984,-0.277411937713623,-0.6235420703887939,-0.3829538822174072,0.3945446014404297,0.7715153694152832,0.8576750755310059,1.337709426879883,1.691303253173828,1.303550004959106,0.529477596282959,0.1013743877410889,0.310516357421875,0.6555640697479248,0.8482527732849121,1.034661531448364,0.9750819206237793,0.4999053478240967,0.0600588321685791,0.09281277656555176,0.1880133152008057,-0.1472711563110352,-0.6216287612915039,-1.118932962417603,-1.366689205169678,-0.9072411060333252,-0.5084538459777832,-0.6093871593475342,-0.7253527641296387,-0.4379677772521973,-0.209352970123291,-0.324549674987793,-0.2666282653808594,-0.0343167781829834,-0.1675069332122803,-0.4922187328338623,-0.9181034564971924,-1.546694040298462,-1.662530899047852,-0.9607768058776855,-0.499645471572876,-0.570981502532959,-0.2025628089904785,0.2939009666442871,0.1883184909820557,-0.3663063049316406,-1.103343963623047,-1.743674278259277,-2.179098129272461,-2.246301174163818,-1.740002632141113,-0.9441184997558594,-0.4197263717651367,-0.3241658210754395,-0.4633259773254395,-0.5858492851257324,-0.3983378410339355,0.04627466201782227,0.3319871425628662,0.1431441307067871,-0.4664075374603271,-1.099315881729126,-1.444909572601318,-1.529884338378906,-0.8725738525390625,0.7697093486785889,2.250895500183105,2.990792989730835,3.316941261291504,3.33645224571228,3.10009241104126,2.423558235168457,0.9253573417663574,0.2525222301483154,1.066228151321411,1.545180082321167,1.759769916534424,2.725626230239868,3.706532716751099,4.275252819061279,4.496036767959595,4.610569477081299,5.109567642211914,5.279829502105713,4.844145774841309,4.359273910522461,4.064918756484985,3.764463663101196,3.35747241973877,3.271743059158325,3.372536897659302,2.728990316390991,2.343498468399048,2.857670783996582,2.718334197998047,2.138770818710327,2.580128908157349,3.919575214385986,4.803750514984131,4.619516134262085,3.731160163879395,3.409746885299683,3.809378147125244,3.533369302749634,2.535947561264038,1.886062622070312,1.586565971374512,1.220985651016235,1.206666231155396,2.650988101959229,4.005299806594849,3.845423460006714,2.817054986953735,1.341162919998169,0.4421460628509521,-0.1372170448303223,-1.349912881851196,-2.090847492218018,-2.145564556121826,-2.402411699295044,-2.528510093688965,-2.236508131027222,-1.856116056442261,-1.367247104644775,-0.722813606262207,-0.4224932193756104,-0.6854963302612305,-1.424915790557861,-2.306300401687622,-2.585968971252441,-2.974522113800049,-3.47941517829895,-3.46144437789917,-2.996758222579956,-2.839914560317993,-2.709372043609619,-2.283579111099243,-1.864449977874756,-1.513241529464722,-1.423319578170776,-2.319833040237427,-2.891298532485962,-3.265906572341919,-3.734608888626099,-3.902616500854492,-2.717293500900269,-0.9358322620391846,-0.04700660705566406,0.3032147884368896,0.4549086093902588,0.6966209411621094,0.7590830326080322,0.5409443378448486,0.1715195178985596,-0.328599214553833,-0.5953121185302734,-0.5576825141906738,-0.5263638496398926,-0.3783249855041504,-0.08019328117370605,0.1041436195373535,0.193784236907959,0.2315676212310791,0.2163529396057129,0.1946079730987549,0.217205286026001,0.2524375915527344,0.2309644222259521,0.2167832851409912,0.2667796611785889,0.3391373157501221,0.347740650177002,0.2760601043701172,0.2015352249145508,0.1757633686065674,0.1849544048309326,0.2141392230987549,0.280684232711792,0.3473889827728271,0.3368926048278809,0.2695298194885254,0.1904106140136719,0.1460552215576172,0.1733863353729248,0.2130019664764404,0.2041482925415039,0.1970779895782471,0.1896405220031738,0.1539289951324463,0.1092410087585449,0.06224989891052246,0.03613829612731934,0.09430766105651855,0.1766526699066162,0.2084219455718994,0.1899623870849609,0.1326847076416016,0.08244752883911133,0.04769802093505859,0.05645990371704102,0.09833812713623047,0.1227593421936035,0.1000022888183594,0.04707694053649902,-0.005643367767333984,-0.00937342643737793,0.05358457565307617,0.1200425624847412,0.1153445243835449,0.04987001419067383,0.02766609191894531,0.0266575813293457,0.007165670394897461,0.005290508270263672,0.0472867488861084,0.09425997734069824,0.07097125053405762,-0.01436114311218262,-0.06903290748596191,-0.06783723831176758,-0.05415916442871094,-0.04389405250549316,-0.01117229461669922,0.01057982444763184,-0.03829717636108398,-0.1025927066802979,-0.1397454738616943,-0.160975456237793,-0.1345133781433105,-0.06956696510314941,-0.05701422691345215,-0.1206886768341064,-0.1860690116882324,-0.1915907859802246,-0.1371347904205322,-0.1083898544311523,-0.0980067253112793,-0.08524894714355469,-0.07873773574829102,-0.07860064506530762,-0.07237553596496582,-0.06472349166870117,-0.04564523696899414,-0.01024007797241211,0.0366973876953125,0.07793068885803223,0.08085250854492188,0.04235625267028809,0.01232743263244629,0.02943873405456543,0.06078124046325684,0.07568240165710449,0.08864402770996094,0.09879827499389648,0.06953716278076172,0.02905607223510742,0.03434062004089355,0.06332159042358398,0.06274104118347168,0.04572272300720215,0.04533767700195312,0.04696369171142578,0.02425432205200195,5.602836608886719e-05,-0.01745462417602539,-0.02093791961669922,-0.01394152641296387,0.0135338306427002,0.04263043403625488,0.05063056945800781,0.06676793098449707,0.1011276245117188,0.1318073272705078,0.1429295539855957,0.1410031318664551,0.1423990726470947,0.1445245742797852,0.1391899585723877,0.1215827465057373,0.08920192718505859,0.0490725040435791,0.02143740653991699,0.009175539016723633,-0.00972747802734375,-0.03505587577819824,-0.04953861236572266,-0.0593721866607666,-0.09613752365112305,-0.1765811443328857,-0.2769041061401367,-0.3450179100036621,-0.3810596466064453,-0.3918087482452393,-0.3553831577301025,-0.3190815448760986,-0.3025925159454346,-0.2972412109375,-0.3004622459411621,-0.3158211708068848,-0.3498315811157227,-0.3847241401672363,-0.3792095184326172,-0.3447318077087402,-0.3160429000854492,-0.3060722351074219,-0.302811861038208,-0.2733182907104492,-0.2175593376159668,-0.176163911819458,-0.1588118076324463,-0.1511275768280029,-0.1526999473571777,-0.1562643051147461,-0.1681137084960938,-0.1805531978607178,-0.1908719539642334,-0.201115608215332,-0.2182400226593018,-0.2182590961456299,-0.1856136322021484,-0.1498007774353027,-0.1396405696868896,-0.1342642307281494,-0.1265823841094971,-0.1262772083282471,-0.1293265819549561,-0.1320195198059082,-0.1365280151367188,-0.1255118846893311,-0.08949637413024902,-0.03397583961486816,0.003527402877807617,-0.0007772445678710938,-0.03220677375793457,-0.0607764720916748,-0.08167505264282227,-0.09618043899536133,-0.1057422161102295,-0.1055753231048584,-0.09764552116394043,-0.1032984256744385,-0.09282112121582031,-0.06340861320495605,-0.03337621688842773,-0.009969472885131836,0.006673336029052734,0.03208398818969727,0.06783366203308105,0.09259223937988281,0.1026427745819092,0.1148772239685059,0.1494491100311279,0.1824951171875,0.1994144916534424,0.2049064636230469,0.2272236347198486,0.2341997623443604,0.231630802154541,0.2283716201782227,0.2274429798126221,0.2413380146026611,0.2698600292205811,0.2916836738586426,0.3033983707427979,0.3112196922302246,0.3122377395629883,0.3336179256439209,0.3651964664459229,0.3987586498260498,0.4330408573150635,0.4441606998443604,0.441049337387085,0.4448151588439941,0.4558074474334717,0.4525244235992432,0.4397451877593994,0.4348814487457275,0.4292905330657959,0.4182350635528564,0.4021668434143066,0.4052424430847168,0.4292190074920654,0.4683399200439453,0.4835987091064453,0.4614448547363281,0.4402828216552734,0.4419863224029541,0.4472589492797852,0.4568672180175781,0.4750680923461914,0.4871857166290283,0.4927444458007812,0.5096709728240967,0.5205142498016357,0.5377006530761719,0.5536139011383057,0.5631732940673828,0.5714154243469238,0.56007981300354,0.5483591556549072,0.5217218399047852,0.4844272136688232,0.4558825492858887,0.443878173828125,0.4223322868347168,0.4045462608337402,0.3880906105041504,0.3612017631530762,0.3351998329162598,0.3190994262695312,0.2996265888214111,0.2763724327087402,0.2610230445861816,0.2445614337921143,0.2238523960113525,0.19736647605896,0.1786386966705322,0.1674735546112061,0.1621663570404053,0.1564478874206543,0.1394116878509521,0.1193869113922119,0.1062250137329102,0.09183049201965332,0.07994294166564941,0.07701992988586426,0.07414817810058594,0.08810877799987793,0.1112353801727295,0.1252353191375732,0.1189589500427246,0.09584426879882812,0.07337093353271484,0.07148265838623047,0.09485960006713867,0.1149654388427734,0.1159274578094482,0.1171934604644775,0.1198148727416992,0.1097607612609863,0.08809804916381836,0.05454063415527344,0.02172231674194336,0.005716085433959961,-0.006089210510253906,-0.01067042350769043,-0.008687973022460938,0.002678632736206055,0.0009930133819580078,-0.02080798149108887,-0.05155563354492188,-0.07521152496337891,-0.08492112159729004,-0.08063077926635742,-0.07596731185913086,-0.0886690616607666,-0.1037359237670898,-0.08769631385803223,-0.06246089935302734,-0.04819869995117188,-0.05473852157592773,-0.08653044700622559,-0.1148080825805664,-0.1209139823913574,-0.1126635074615479,-0.1150369644165039,-0.1287341117858887,-0.1471936702728271,-0.154881477355957,-0.1530313491821289,-0.1443624496459961,-0.1253652572631836,-0.1004552841186523,-0.07969856262207031,-0.07942676544189453,-0.09464740753173828,-0.0974738597869873,-0.08710980415344238,-0.07178783416748047,-0.06737709045410156,-0.06074905395507812,-0.05656957626342773,-0.05556464195251465,-0.0706183910369873,-0.08406996726989746,-0.0763094425201416,-0.04277706146240234,0.004447698593139648,0.04522800445556641,0.06337881088256836,0.06149172782897949,0.04648447036743164,0.03232121467590332,0.04644989967346191,0.06343245506286621,0.0497889518737793,0.02979874610900879,0.02462148666381836,0.04340767860412598,0.06722211837768555,0.07973790168762207,0.08661746978759766,0.09155154228210449,0.09449481964111328,0.09548783302307129,0.09913444519042969,0.09012579917907715,0.07726550102233887,0.06828784942626953,0.05962610244750977,0.05929708480834961,0.05996227264404297,0.04864811897277832,0.02746939659118652,0.01025676727294922,0.003511905670166016,0.01093149185180664,0.01989245414733887,0.02019882202148438,0.001691579818725586,-0.01674890518188477,-0.01518607139587402,-0.008219480514526367,-0.01588702201843262,-0.02903223037719727,-0.01455426216125488,0.002661943435668945,0.01103043556213379,-0.006271600723266602,-0.03085613250732422,-0.04322528839111328,-0.0295865535736084,0.01275777816772461,0.05318999290466309,0.06168842315673828,0.05684852600097656,0.0363767147064209,0.02252101898193359,0.02777457237243652,0.02773642539978027,0.03186702728271484,0.0586390495300293,0.09160757064819336,0.1098811626434326,0.1221609115600586,0.136570930480957,0.1413512229919434,0.1243555545806885,0.1073896884918213,0.09361028671264648,0.07551431655883789,0.07412433624267578,0.09181499481201172,0.09999752044677734,0.08115887641906738,0.07519125938415527,0.09748101234436035,0.1327109336853027,0.1695585250854492,0.1726162433624268,0.1539158821105957,0.1419985294342041,0.1569044589996338,0.1826119422912598,0.195235013961792,0.1940333843231201,0.2056252956390381,0.2190113067626953,0.2304768562316895,0.2444183826446533,0.2554261684417725,0.2615678310394287,0.2779614925384521,0.2937424182891846,0.3034913539886475,0.317918062210083,0.3277158737182617,0.3518581390380859,0.3877413272857666,0.4067826271057129,0.4101788997650146,0.4151880741119385,0.4094624519348145,0.3954696655273438,0.3958797454833984,0.3969955444335938,0.398106575012207,0.4105710983276367,0.4222691059112549,0.4168474674224854,0.4033303260803223,0.3817498683929443,0.3595304489135742,0.3452050685882568,0.3307819366455078,0.3107595443725586,0.3021442890167236,0.3056669235229492,0.2945828437805176,0.2747750282287598,0.259937047958374,0.2420496940612793,0.2153944969177246,0.1995694637298584,0.1967501640319824,0.2065479755401611,0.2260899543762207,0.2469825744628906,0.2567601203918457,0.2487719058990479,0.2381527423858643,0.2289199829101562,0.217815637588501,0.1980793476104736,0.1813781261444092,0.1729774475097656,0.1622354984283447,0.1576876640319824,0.1578593254089355,0.1416420936584473,0.1234531402587891,0.1195442676544189,0.1343834400177002,0.1446795463562012,0.1548898220062256,0.1472151279449463,0.1399290561676025,0.1253366470336914,0.1199734210968018,0.1520299911499023,0.1822423934936523,0.1887595653533936,0.2016746997833252,0.2091217041015625,0.2024531364440918,0.1864981651306152,0.1914763450622559,0.2020156383514404,0.1929104328155518,0.1733887195587158,0.1478302478790283,0.1277840137481689,0.1313555240631104,0.128180980682373,0.1055562496185303,0.08407950401306152,0.06524443626403809,0.04876017570495605,0.03882765769958496,0.04939436912536621,0.06457209587097168,0.07980704307556152,0.08675932884216309,0.07045507431030273,0.05634784698486328,0.03744840621948242,0.0254666805267334,0.01710176467895508,0.01838922500610352,0.03574252128601074,0.05168437957763672,0.03554701805114746,0.01564145088195801,0.02866864204406738,0.02703189849853516,0.01001596450805664,0.02112269401550293,0.04456400871276855,0.05544662475585938,0.05585432052612305,0.05370020866394043,0.05936741828918457,0.08363008499145508,0.1112830638885498,0.1318609714508057,0.145719051361084,0.1494252681732178,0.1419937610626221,0.1342129707336426,0.1438581943511963,0.1626181602478027,0.1723062992095947,0.1842331886291504,0.1973140239715576,0.21445631980896,0.2418422698974609,0.2705562114715576,0.2846419811248779,0.2923727035522461,0.2725446224212646,0.2543771266937256,0.2502775192260742,0.2433943748474121,0.2178657054901123,0.1978158950805664,0.1921617984771729,0.1817572116851807,0.1743757724761963,0.1600813865661621,0.1267087459564209,0.09802341461181641,0.08868932723999023,0.06449103355407715,0.02253293991088867,-0.003898143768310547,-0.02124190330505371,-0.05943179130554199,-0.0851142406463623,-0.08728861808776855,-0.1061344146728516,-0.1222562789916992,-0.1201999187469482,-0.1311254501342773,-0.1653432846069336,-0.1887404918670654,-0.1901853084564209,-0.1935184001922607,-0.2039456367492676,-0.2006745338439941,-0.1921355724334717,-0.1752352714538574,-0.1425027847290039,-0.1424455642700195,-0.1605844497680664,-0.1618492603302002,-0.1430320739746094,-0.1273882389068604,-0.1211607456207275,-0.1417839527130127,-0.1684188842773438,-0.1730895042419434,-0.1748049259185791,-0.1647078990936279,-0.1304519176483154,-0.1035606861114502,-0.1007413864135742,-0.08757948875427246,-0.07286667823791504,-0.06478428840637207,-0.04525542259216309,-0.02771854400634766,-0.02181172370910645,-0.009548664093017578,0.01375794410705566,0.02258777618408203,0.01608014106750488,0.01635074615478516,0.0353848934173584,0.05257725715637207,0.05040526390075684,0.05388975143432617,0.08741974830627441,0.1172447204589844,0.141298770904541,0.1645267009735107,0.1794338226318359,0.1913249492645264,0.1887738704681396,0.1728367805480957,0.1650166511535645,0.1789259910583496,0.198599100112915,0.191953182220459,0.1701116561889648,0.163806676864624,0.1876199245452881,0.2175760269165039,0.2363085746765137,0.2395725250244141,0.2386116981506348,0.2601563930511475,0.2836453914642334,0.2898192405700684,0.2927756309509277,0.2907633781433105,0.2931308746337891,0.2992963790893555,0.2987861633300781,0.3076469898223877,0.3196918964385986,0.3092360496520996,0.2851080894470215,0.2580678462982178,0.2449262142181396,0.2307462692260742,0.2293789386749268,0.2407717704772949,0.2643501758575439,0.2807128429412842,0.2756345272064209,0.2650332450866699,0.2637863159179688,0.2731883525848389,0.2802920341491699,0.2752816677093506,0.2564191818237305,0.241471529006958,0.2368855476379395,0.2430760860443115,0.2529776096343994,0.2636003494262695,0.2553832530975342,0.2116990089416504,0.1988840103149414,0.2286934852600098,0.2341699600219727,0.2005159854888916,0.1827287673950195,0.180823802947998,0.1885771751403809,0.1973640918731689,0.2010452747344971,0.19325852394104,0.1845824718475342,0.1685357093811035,0.156867504119873,0.1453077793121338,0.1437652111053467,0.1481771469116211,0.1550436019897461,0.1512622833251953,0.1432979106903076,0.1253187656402588,0.08643746376037598,0.03715395927429199,0.002689361572265625,-0.01329541206359863,-0.01371026039123535,-0.01094818115234375,0.002013444900512695,0.03613591194152832,0.04131674766540527,0.01162171363830566,0.01473069190979004,0.01865386962890625,-0.001436471939086914,-0.03584742546081543,-0.07186055183410645,-0.0986015796661377,-0.09733200073242188,-0.06371140480041504,-0.02504825592041016,0.009495019912719727,0.03025412559509277,0.04493117332458496,0.04667043685913086,0.02310991287231445,-0.01361250877380371,-0.04723072052001953,-0.08447408676147461,-0.1193702220916748,-0.09965419769287109,-0.04421353340148926,-0.00510096549987793,0.00346064567565918,0.0007939338684082031,-0.0008690357208251953,0.02053737640380859,0.03984212875366211,0.03881454467773438,0.06735563278198242,0.11993408203125,0.1551902294158936,0.1627302169799805,0.1694357395172119,0.1692771911621094,0.1634824275970459,0.1578652858734131,0.160367488861084,0.180741548538208,0.193864107131958,0.1734542846679688,0.1282155513763428,0.08932352066040039,0.09571075439453125,0.1234877109527588,0.1535511016845703,0.1743423938751221,0.1988637447357178,0.2198696136474609,0.2136552333831787,0.1955783367156982,0.1978099346160889,0.2091443538665771,0.201030969619751,0.1958751678466797,0.2016186714172363,0.2023041248321533,0.22011399269104,0.2523982524871826,0.2559900283813477,0.2470064163208008,0.244135856628418,0.2288544178009033,0.1999616622924805,0.1722824573516846,0.1570510864257812,0.1682090759277344,0.1854836940765381,0.1897192001342773,0.1847004890441895,0.1638174057006836,0.1120531558990479,0.05134701728820801,0.02762198448181152,0.02979874610900879,0.04499197006225586,0.05606293678283691,0.04005074501037598,0.0225532054901123,0.02822160720825195,0.03633856773376465,0.03542661666870117,0.0281071662902832,0.01711726188659668,0.007710456848144531,0.009477138519287109,0.01809120178222656,0.02472996711730957,0.0245356559753418,0.02676129341125488,0.0374758243560791,0.0592648983001709,0.0867915153503418,0.09285926818847656,0.08254170417785645,0.08381009101867676,0.08974194526672363,0.1236641407012939,0.1679062843322754,0.1678156852722168,0.1547634601593018,0.1577317714691162,0.1566517353057861,0.1811730861663818,0.2093207836151123,0.2051699161529541,0.1903069019317627,0.1967120170593262,0.21331787109375,0.221714973449707,0.2217352390289307,0.2271342277526855,0.2631139755249023,0.2953505516052246,0.3008902072906494,0.301746129989624,0.2886390686035156,0.2523553371429443,0.2020382881164551,0.1603531837463379,0.1554012298583984,0.1677536964416504,0.1820170879364014,0.1940155029296875,0.1943790912628174,0.2030777931213379,0.2092432975769043,0.1957798004150391,0.1942968368530273,0.2145612239837646,0.2282524108886719,0.2258014678955078,0.2246272563934326,0.2311480045318604,0.239490270614624,0.2227187156677246,0.1789402961730957,0.1414203643798828,0.1102268695831299,0.07189393043518066,0.03751039505004883,0.01691222190856934,0.001559257507324219,-0.0121915340423584,-0.04346966743469238,-0.08487582206726074,-0.1042318344116211,-0.09026646614074707,-0.06746292114257812,-0.0563347339630127,-0.05905866622924805,-0.0738072395324707,-0.09045958518981934,-0.1205205917358398,-0.1322352886199951,-0.1247298717498779,-0.1181423664093018,-0.113825798034668,-0.102541446685791,-0.09674906730651855,-0.08922100067138672,-0.06710290908813477,-0.06162524223327637,-0.07449150085449219,-0.1004362106323242,-0.1212847232818604,-0.1241350173950195,-0.1134562492370605,-0.1180291175842285,-0.1257419586181641,-0.1262736320495605,-0.1189720630645752,-0.1094841957092285,-0.1016676425933838,-0.09293317794799805,-0.0764167308807373,-0.01734495162963867,0.03415703773498535,0.05222678184509277,0.06128787994384766,0.06976127624511719,0.04948854446411133,0.05799651145935059,0.09993076324462891,0.1014649868011475,0.08019685745239258,0.07726550102233887,0.08535623550415039,0.1059412956237793,0.1335537433624268,0.1497101783752441,0.1555466651916504,0.1500368118286133,0.1533782482147217,0.1691198348999023,0.1684403419494629,0.1331281661987305,0.14137864112854,0.1747870445251465,0.199735164642334,0.2057731151580811,0.2033424377441406,0.2309274673461914,0.2867913246154785,0.3036618232727051,0.273510217666626,0.2422881126403809,0.229039192199707,0.246884822845459,0.2629566192626953,0.2637279033660889,0.2686226367950439,0.2745902538299561,0.2534925937652588,0.2106344699859619,0.1825892925262451,0.1836442947387695,0.2235782146453857,0.2863156795501709,0.2963387966156006,0.2565252780914307,0.2508938312530518,0.252450704574585,0.2148222923278809,0.1529455184936523,0.1143002510070801,0.09978175163269043,0.08307456970214844,0.04729509353637695,0.000438690185546875,-0.01932382583618164,-0.02122640609741211,-0.01256108283996582,0.003105401992797852,-0.02060294151306152,-0.07030963897705078,-0.08706212043762207,-0.09146451950073242,-0.122826099395752,-0.1344025135040283,-0.106356143951416,-0.0798344612121582,-0.07783651351928711,-0.06657004356384277,-0.0504302978515625,-0.05930423736572266,-0.07912993431091309,-0.1048958301544189,-0.1336491107940674,-0.1331853866577148,-0.1296818256378174,-0.1928973197937012,-0.2512550354003906,-0.2271318435668945,-0.1623344421386719,-0.1183545589447021,-0.0853574275970459,-0.05907416343688965,-0.04976391792297363,-0.05048632621765137,-0.04652976989746094,0.003260374069213867,0.0762331485748291,0.08780717849731445,0.06154775619506836,0.05389571189880371,0.04647612571716309,0.07732748985290527,0.1375651359558105,0.1441657543182373,0.114436149597168,0.1227772235870361,0.1600778102874756,0.2063643932342529,0.2443110942840576,0.2202630043029785,0.1686334609985352,0.1430916786193848,0.1539421081542969,0.1723647117614746,0.1951706409454346,0.2348387241363525,0.2624022960662842,0.2795445919036865,0.2967798709869385,0.2801847457885742,0.259251594543457,0.2705848217010498,0.2613270282745361,0.2377033233642578,0.2489864826202393,0.2736306190490723,0.274045467376709,0.2405083179473877,0.2068901062011719,0.1769614219665527,0.2089965343475342,0.2750885486602783,0.2655279636383057,0.2202308177947998,0.2005863189697266,0.2069056034088135,0.2227497100830078,0.2012646198272705,0.1318240165710449,0.1050102710723877,0.1567792892456055,0.1946532726287842,0.181889533996582,0.1320302486419678,0.1359391212463379,0.2168679237365723,0.2510273456573486,0.1871621608734131,0.1204502582550049,0.1404809951782227,0.234149694442749,0.2773094177246094,0.2078461647033691,0.1368141174316406,0.1377105712890625,0.1916968822479248,0.2480053901672363,0.2493965625762939,0.2255117893218994,0.264817476272583,0.3229892253875732,0.2711677551269531,0.179450511932373,0.1634669303894043,0.2120697498321533,0.2963793277740479,0.347822904586792,0.3302955627441406,0.2879345417022705,0.2841770648956299,0.3144752979278564,0.3314042091369629,0.2576422691345215,0.1601099967956543,0.1292085647583008,0.108952522277832,0.06862044334411621,0.02927541732788086,-0.01717448234558105,-0.03009200096130371,-0.01039862632751465,-0.03136754035949707,-0.09167790412902832,-0.1065576076507568,-0.08159279823303223,-0.06208300590515137,-0.04420280456542969,-0.02400994300842285,-0.02106308937072754,-0.01191973686218262,-0.001087188720703125,0.005964040756225586,0.02617478370666504,0.04883289337158203,0.04152417182922363,0.007723569869995117,-0.01043796539306641,0.02318620681762695,0.0656425952911377,0.05557060241699219,0.02970457077026367,0.03038287162780762,0.04882574081420898,0.08856534957885742,0.1329386234283447,0.1323449611663818,0.116417407989502,0.1237428188323975,0.1212906837463379,0.1049184799194336,0.08874654769897461,0.0923609733581543,0.1307129859924316,0.1925039291381836,0.2065896987915039,0.1106178760528564,0.002939701080322266,0.003561973571777344,0.02464413642883301,0.009579658508300781,-0.008612871170043945,-0.04702091217041016,-0.09878873825073242,-0.09648561477661133,-0.05935311317443848,-0.06873607635498047,-0.1135945320129395,-0.1484179496765137,-0.138239860534668,-0.1174676418304443,-0.1197052001953125,-0.1079869270324707,-0.1056849956512451,-0.1052737236022949,-0.07547736167907715,-0.05302786827087402,-0.0559544563293457,-0.06765127182006836,-0.07190823554992676,-0.06577134132385254,-0.04926800727844238,-0.0493323802947998,-0.05842447280883789,-0.0544428825378418,-0.03564596176147461,-0.02887129783630371,-0.0274348258972168,-0.006135702133178711,0.03519058227539062,0.06180644035339355,0.06513237953186035,0.0652015209197998,0.06477713584899902,0.03806710243225098,0.01241922378540039,0.0165092945098877,0.01708149909973145,-0.00561833381652832,-0.009306669235229492,0.008647441864013672,0.002751350402832031,-0.0274050235748291,-0.03230571746826172,-0.007764101028442383,0.01980781555175781,0.03361225128173828,0.02252459526062012,0.01492619514465332,0.02804756164550781,0.04888653755187988,0.05966663360595703,0.07034897804260254,0.05583882331848145,0.03597140312194824,0.03216385841369629,0.04389166831970215,0.05580544471740723,0.04783391952514648,0.02453923225402832,0.02145886421203613,0.03906965255737305,0.04741549491882324,0.0540626049041748,0.06975889205932617,0.06993412971496582,0.03745794296264648,-0.01436710357666016,-0.03121852874755859,-0.02013683319091797,-0.01934647560119629,-0.05179524421691895,-0.08682966232299805,-0.1003110408782959,-0.0844109058380127,-0.07546782493591309,-0.0906682014465332,-0.1081180572509766,-0.1210343837738037,-0.1206839084625244,-0.0864720344543457,-0.05974054336547852,-0.05010128021240234,-0.03960132598876953,-0.0464630126953125,-0.05607485771179199,-0.03330230712890625,0.003380775451660156,0.03186702728271484,0.03839850425720215,0.03509640693664551,0.05470514297485352,0.1316678524017334,0.1998805999755859,0.2218365669250488,0.2403414249420166,0.2805173397064209,0.3639650344848633,0.4463350772857666,0.4864144325256348,0.4805850982666016,0.4577696323394775,0.4183542728424072,0.3580033779144287,0.3168344497680664,0.3059673309326172,0.285874605178833,0.2796673774719238,0.3025507926940918,0.3182899951934814,0.3388094902038574,0.3527939319610596,0.3295648097991943,0.2902114391326904,0.2849364280700684,0.2639985084533691,0.21872878074646,0.1965177059173584,0.1999509334564209,0.1985526084899902,0.2048790454864502,0.1804971694946289,0.1068997383117676,0.05110025405883789,0.02432942390441895,-0.01739978790283203,-0.06772637367248535,-0.1094317436218262,-0.151066780090332,-0.1743769645690918,-0.1782488822937012,-0.1735448837280273,-0.1634359359741211,-0.1539909839630127,-0.1484382152557373,-0.1479792594909668,-0.1476025581359863,-0.1408648490905762,-0.1412200927734375,-0.1495730876922607,-0.1517403125762939,-0.1994526386260986,-0.2775335311889648,-0.3285884857177734,-0.3660643100738525,-0.4021358489990234,-0.4134559631347656,-0.405580997467041,-0.3971540927886963,-0.365976095199585,-0.2902483940124512,-0.2467691898345947,-0.2663230895996094,-0.2780663967132568,-0.2704977989196777,-0.2611768245697021,-0.2356529235839844,-0.1623046398162842,-0.07052898406982422,0.007866621017456055,0.05828142166137695,0.03823995590209961,0.03142833709716797,0.08271098136901855,0.1244914531707764,0.1325356960296631,0.1521766185760498,0.1625657081604004,0.1691114902496338,0.178602933883667,0.2052819728851318,0.2435219287872314,0.2596735954284668,0.2567410469055176,0.2834236621856689,0.3429567813873291,0.3813660144805908,0.3928196430206299,0.3880703449249268,0.3706908226013184,0.3381991386413574,0.2822422981262207,0.2302002906799316,0.2036523818969727,0.1878929138183594,0.1912975311279297,0.2301633358001709,0.2546167373657227,0.2430093288421631,0.2269136905670166,0.2097201347351074,0.1935887336730957,0.1848089694976807,0.1951861381530762,0.2132594585418701,0.2273774147033691,0.2264201641082764,0.2370095252990723,0.2634274959564209,0.2671456336975098,0.2521669864654541,0.2414405345916748,0.2200126647949219,0.17799973487854,0.1359212398529053,0.1285684108734131,0.1332783699035645,0.1252865791320801,0.1136612892150879,0.1168954372406006,0.1161706447601318,0.1145255565643311,0.1217961311340332,0.1215481758117676,0.1299154758453369,0.1367688179016113,0.1268923282623291,0.1444900035858154,0.1480019092559814,0.1191675662994385,0.107342004776001,0.1035702228546143,0.06095647811889648,0.03530502319335938,0.04878878593444824,0.03087520599365234,-0.002561807632446289,-0.003590583801269531,-0.00756382942199707,-0.02489089965820312,-0.02254724502563477,-0.01797199249267578,-0.0273895263671875,-0.02430200576782227,-0.0212252140045166,-0.03861427307128906,-0.06739139556884766,-0.09014010429382324,-0.1004207134246826,-0.1009285449981689,-0.106048583984375,-0.09507179260253906,-0.09507298469543457,-0.1320970058441162,-0.1778233051300049,-0.2021133899688721,-0.2202010154724121,-0.2451443672180176,-0.2454888820648193,-0.251237154006958,-0.2732312679290771,-0.2933919429779053,-0.3111350536346436,-0.334017276763916,-0.3531599044799805,-0.3592503070831299,-0.3430235385894775,-0.3473269939422607,-0.3792989253997803,-0.4126179218292236,-0.3911113739013672,-0.3322207927703857,-0.2848172187805176,-0.2657735347747803,-0.2848446369171143,-0.2628672122955322,-0.2323627471923828,-0.2254891395568848,-0.2177441120147705,-0.1690328121185303,-0.1110935211181641,-0.0778663158416748,-0.06225228309631348,-0.06177306175231934,-0.06875753402709961,-0.06437540054321289,-0.03821372985839844,0.002640485763549805,0.06500005722045898,0.1246726512908936,0.1372826099395752,0.1364588737487793,0.1382267475128174,0.1173079013824463,0.09420990943908691,0.07325053215026855,0.05078554153442383,0.0378572940826416,0.02639055252075195,0.03885149955749512,0.08039116859436035,0.07102131843566895,0.006843805313110352,-0.04325628280639648,-0.0602114200592041,-0.04932641983032227,-0.01672863960266113,-0.01410007476806641,-0.009174346923828125,0.03582239151000977,0.05045533180236816,0.02675533294677734,0.0296318531036377,0.03571033477783203,0.02312421798706055,0.02165317535400391,0.0177764892578125,0.01350045204162598,0.03216266632080078,0.05920886993408203,0.06157279014587402,0.06354331970214844,0.08786201477050781,0.1091527938842773,0.1169812679290771,0.1282083988189697,0.1501178741455078,0.1796448230743408,0.1870632171630859,0.1634097099304199,0.1598894596099854,0.1945972442626953,0.1937389373779297,0.1540839672088623,0.1373720169067383,0.1341450214385986,0.1037061214447021,0.09070992469787598,0.0934910774230957,0.07846355438232422,0.06377339363098145,0.04411101341247559,0.03457784652709961,0.0677490234375,0.1043009757995605,0.09617328643798828,0.07064223289489746,0.08141875267028809,0.1016318798065186,0.1321208477020264,0.1587080955505371,0.1247119903564453,0.06600260734558105,0.03705024719238281,0.01415491104125977,-0.006598234176635742,-0.001773834228515625,0.0292658805847168,0.07117390632629395,0.1068675518035889,0.1278650760650635,0.1046383380889893,0.07917881011962891,0.08355975151062012,0.1526570320129395,0.2337062358856201,0.2535760402679443,0.2515590190887451,0.2584421634674072,0.2462577819824219,0.2078831195831299,0.1964056491851807,0.1823019981384277,0.1365923881530762,0.1022088527679443,0.09704470634460449,0.1189589500427246,0.1243984699249268,0.1191413402557373,0.1237523555755615,0.1276516914367676,0.1032781600952148,0.06551027297973633,0.02593755722045898,-0.01775026321411133,-0.03620505332946777,-0.03137707710266113,-0.04287958145141602,-0.04027366638183594,-0.04867792129516602,-0.08962631225585938,-0.1260232925415039,-0.1289689540863037,-0.1268208026885986,-0.1262009143829346,-0.1007068157196045,-0.06712913513183594,-0.04669427871704102,-0.02169966697692871,-0.004191398620605469,-0.01538515090942383,-0.01461148262023926,0.01421332359313965,0.06209373474121094,0.124819278717041,0.206829309463501,0.2356719970703125,0.2187788486480713,0.20455002784729,0.2077877521514893,0.2162039279937744,0.2329063415527344,0.2752768993377686,0.3304171562194824,0.3635537624359131,0.3544950485229492,0.3062283992767334,0.2817273139953613,0.3368854522705078,0.3916728496551514,0.3707718849182129,0.3618192672729492,0.4027247428894043,0.4322898387908936,0.4496335983276367,0.4650390148162842,0.4060459136962891,0.3354430198669434,0.3476095199584961,0.402597188949585,0.4473018646240234,0.4566967487335205,0.4410195350646973,0.4325175285339355,0.4474127292633057,0.4990935325622559,0.5433821678161621,0.5965101718902588,0.6510448455810547,0.6879317760467529,0.7357382774353027,0.7715761661529541,0.7715225219726562,0.7602810859680176,0.7399380207061768,0.6905889511108398,0.6281721591949463,0.6016683578491211,0.5625951290130615,0.4776895046234131,0.4457581043243408,0.457991361618042,0.4368054866790771,0.4023516178131104,0.3839433193206787,0.3771102428436279,0.3803658485412598,0.3793144226074219,0.3589546680450439,0.3547894954681396,0.3535425662994385,0.3437185287475586,0.3022646903991699,0.2703940868377686,0.2905154228210449,0.3105902671813965,0.3123831748962402,0.3380703926086426,0.3580272197723389,0.3433048725128174,0.3349936008453369,0.3234577178955078,0.2880990505218506,0.2959275245666504,0.3108549118041992,0.320059061050415,0.3274548053741455,0.2995145320892334,0.2498197555541992,0.2181446552276611,0.2171421051025391,0.2297806739807129,0.2494132518768311,0.1989960670471191,0.09324789047241211,0.02452969551086426,0.01659274101257324,0.06032347679138184,0.1144695281982422,0.1276564598083496,0.09229660034179688,0.06745576858520508,0.0984346866607666,0.1662826538085938,0.1940536499023438,0.1741874217987061,0.1129293441772461,0.01766562461853027,-0.04390597343444824,-0.1068806648254395,-0.1827442646026611,-0.2228200435638428,-0.2569925785064697,-0.3216743469238281,-0.3286147117614746,-0.2600157260894775,-0.2528524398803711,-0.2980434894561768,-0.3484082221984863,-0.3832602500915527,-0.3394961357116699,-0.273822546005249,-0.2585232257843018,-0.2283167839050293,-0.1834475994110107,-0.1784086227416992,-0.1576721668243408,-0.1158630847930908,-0.137028694152832,-0.1785850524902344,-0.1604211330413818,-0.08933663368225098,-0.010528564453125,0.01337528228759766,-0.02149105072021484,-0.0735175609588623,-0.08414030075073242,-0.01664996147155762,0.06340265274047852,0.1183342933654785,0.160520076751709,0.1778686046600342,0.1849126815795898,0.1792824268341064,0.08611202239990234,-0.03437280654907227,-0.04839897155761719,-0.01154899597167969,-0.007314682006835938,-0.00988006591796875,-0.02152800559997559,-0.03360271453857422,-0.02440690994262695,-0.003809928894042969,-0.01169919967651367,-0.02889394760131836,0.02596855163574219,0.08934617042541504,0.09092807769775391,0.08543729782104492,0.0822758674621582,0.04749894142150879,-0.02704501152038574,-0.099945068359375,-0.1412630081176758,-0.1499724388122559,-0.1584064960479736,-0.1971161365509033,-0.255507230758667,-0.2624297142028809,-0.1846766471862793,-0.1442909240722656,-0.1373231410980225,-0.09512543678283691,-0.06098747253417969,-0.05295991897583008,-0.06520867347717285,-0.08943796157836914,-0.1017618179321289,-0.05006909370422363,0.0118553638458252,0.02295374870300293,0.01597881317138672,0.04749894142150879,0.09083390235900879,0.0612342357635498,0.02460360527038574,-0.01362204551696777,-0.003165006637573242,0.04485249519348145,0.06955146789550781,0.05596041679382324,-0.00849604606628418,-0.07593631744384766,-0.1304233074188232,-0.1742815971374512,-0.1892721652984619,-0.1611769199371338,-0.09295344352722168,-0.06207466125488281,-0.1423990726470947,-0.2528131008148193,-0.3250157833099365,-0.3957319259643555,-0.4198634624481201,-0.3284347057342529,-0.222022533416748,-0.2038729190826416,-0.1918041706085205,-0.1288175582885742,-0.0867772102355957,-0.05463838577270508,-0.01486420631408691,-0.02106904983520508,-0.06001591682434082,-0.05280613899230957,0.005352497100830078,0.001412630081176758,-0.1053988933563232,-0.1647555828094482,-0.1051568984985352,-0.04196405410766602,-0.005779266357421875,0.04427671432495117,0.05428194999694824,0.07593274116516113,0.1552879810333252,0.2295005321502686,0.2729296684265137,0.2792036533355713,0.2526593208312988,0.2417361736297607,0.2821207046508789,0.3058266639709473,0.2729141712188721,0.2515780925750732,0.3450262546539307,0.4725384712219238,0.5182754993438721,0.5591309070587158,0.6033360958099365,0.5459809303283691,0.4687595367431641,0.4603815078735352,0.4521214962005615,0.4545950889587402,0.5198585987091064,0.5012953281402588,0.3825533390045166,0.3292787075042725,0.3469288349151611,0.3864514827728271,0.3302335739135742,0.2199935913085938,0.2371370792388916,0.3684532642364502,0.4013729095458984,0.2701616287231445,0.2097129821777344,0.2940309047698975,0.3352999687194824,0.2964949607849121,0.2656066417694092,0.2857029438018799,0.3659427165985107,0.4499101638793945,0.4089009761810303,0.2496504783630371,0.2208435535430908,0.3887629508972168,0.4923045635223389,0.4838788509368896,0.4670417308807373,0.4981362819671631,0.5653488636016846,0.5934607982635498,0.6016695499420166,0.6891202926635742,0.8200442790985107,0.8928084373474121,0.8722841739654541,0.819091796875,0.7933545112609863,0.8319461345672607,0.8825874328613281,0.8916819095611572,0.8820223808288574,0.813525915145874,0.7503235340118408,0.7740104198455811,0.8029627799987793,0.8343303203582764,0.8941018581390381,0.9107863903045654,0.9354329109191895,0.9030938148498535,0.7766830921173096,0.7184791564941406,0.7253634929656982,0.7311439514160156,0.7545745372772217,0.8039188385009766,0.7728672027587891,0.6993019580841064,0.6845557689666748,0.7140922546386719,0.7421445846557617,0.7493698596954346,0.7142698764801025,0.6650066375732422,0.6541883945465088,0.6530308723449707,0.6283307075500488,0.6129562854766846,0.6309664249420166,0.6278395652770996,0.5927765369415283,0.5702567100524902,0.5752885341644287,0.5987191200256348,0.551753044128418,0.352550745010376,0.1211750507354736,-0.008006095886230469,-0.1135647296905518,-0.3047120571136475,-0.479658842086792,-0.5341887474060059,-0.513768196105957,-0.4107189178466797,-0.3304505348205566,-0.329660177230835,-0.3439533710479736,-0.3680217266082764,-0.3917062282562256,-0.3348350524902344,-0.2027332782745361,-0.1413810253143311,-0.1530539989471436,-0.2028846740722656,-0.3495609760284424,-0.5275201797485352,-0.6142246723175049,-0.6503689289093018,-0.7346165180206299,-0.8446848392486572,-0.83396315574646,-0.7678115367889404,-0.7482528686523438,-0.745309591293335,-0.6516575813293457,-0.5496871471405029,-0.4876255989074707,-0.3587472438812256,-0.3169965744018555,-0.3263580799102783,-0.3112363815307617,-0.3669500350952148,-0.4089236259460449,-0.4224109649658203,-0.532996654510498,-0.6457376480102539,-0.7374989986419678,-0.7903695106506348,-0.7393360137939453,-0.6362652778625488,-0.5470585823059082,-0.498502254486084,-0.4630684852600098,-0.5602526664733887,-0.6764423847198486,-0.5962491035461426,-0.5859506130218506,-0.6549453735351562,-0.7026243209838867,-0.8440124988555908,-1.189721822738647,-1.438277959823608,-1.35898232460022,-1.194503307342529,-1.081305742263794,-1.197223663330078,-1.502881050109863,-1.564806699752808,-1.338214874267578,-1.234173774719238,-1.230000257492065,-1.100496053695679,-1.2237548828125,-1.413679122924805,-1.321991682052612,-0.9977495670318604,-0.7211470603942871,-0.652698278427124,-0.6304800510406494,-0.6909668445587158,-0.6676733493804932,-0.5568158626556396,-0.6059205532073975,-0.6797826290130615,-0.4909884929656982,-0.4761528968811035,-0.7426261901855469,-0.9283411502838135,-1.24333381652832,-1.472291946411133,-1.227096319198608,-0.876157283782959,-0.5598759651184082,-0.5832469463348389,-1.027525663375854,-1.127693653106689,-0.6734168529510498,-0.2732253074645996,-0.4935085773468018,-1.221268177032471,-1.705770492553711,-1.389124393463135,-0.7909166812896729,-0.6792068481445312,-0.8208358287811279,-0.6952333450317383,-0.4281795024871826,-0.2386355400085449,-0.2737557888031006,-0.1680612564086914,-0.3817963600158691,-0.8244931697845459,-0.7134711742401123,-0.1944315433502197,0.07371783256530762,-0.211188793182373,-0.1213204860687256,0.5109190940856934,0.4976558685302734,0.3722953796386719,0.44991135597229,0.2476000785827637,0.3157186508178711,0.759892463684082,1.264170408248901,1.507127285003662,1.33601188659668,1.046146154403687,1.400517225265503,2.145802974700928,2.214871644973755,1.725755929946899,1.779704093933105,2.109012603759766,2.184563875198364,1.943447589874268,1.469165086746216,1.745803356170654,2.429021596908569,2.301578521728516,1.960655450820923,2.005770206451416,1.94096565246582,2.029819488525391,2.496025562286377,2.477371692657471,2.181968688964844,2.250121831893921,1.995434761047363,1.217861175537109,1.018131971359253,1.2373948097229,1.33962869644165,1.714574098587036,2.374626398086548,2.365809679031372,1.539530754089355,0.8048820495605469,0.4878878593444824,0.6435191631317139,1.246753931045532,1.944092512130737,2.284544706344604,2.280088663101196,2.283651828765869,2.402968406677246,2.597755193710327,2.984628677368164,3.269281387329102,2.931891679763794,2.16640830039978,1.41547679901123,0.9929740428924561,1.153173446655273,1.529998779296875,1.637188196182251,1.450369358062744,0.8943390846252441,0.442662239074707,0.3797996044158936,0.3895902633666992,0.2842235565185547,0.3945457935333252,0.5916690826416016,0.6995809078216553,0.5046796798706055,0.09291529655456543,-0.2815008163452148,-0.3164386749267578,0.1613736152648926,1.101521253585815,-0.5764567852020264,-2.778960466384888,-3.452959060668945,-3.75033974647522,-3.623298406600952,-2.774447202682495,-1.723977327346802,-1.355786323547363,-1.311603784561157,-1.391792297363281,-1.463824510574341,-1.411012411117554,-1.307836771011353,-1.173826456069946,-0.9969675540924072,-0.8916747570037842,-0.9009945392608643,-1.042025089263916,-1.1003577709198,-0.9841275215148926,-1.054228544235229,-1.577492952346802,-2.002681493759155,-2.113111019134521,-2.269349098205566,-2.208163738250732,-1.910364627838135,-1.626577377319336,-1.53028130531311,-1.533830165863037,-1.496179103851318,-1.448637247085571,-1.375352144241333,-1.415948867797852,-1.5204918384552,-1.54215931892395,-1.610903739929199,-1.775195598602295,-1.763647794723511,-1.598665714263916,-1.553133726119995,-1.623122692108154,-1.645240783691406,-1.651828289031982,-1.649408340454102,-1.653347015380859,-1.676342487335205,-1.720110177993774,-1.785887479782104,-1.788334846496582,-1.717467308044434,-1.666183471679688,-1.69406533241272,-1.702728271484375,-1.628667116165161,-1.535391807556152,-1.519159078598022,-1.526808738708496,-1.511059999465942,-1.520133018493652,-1.54229998588562,-1.514402627944946,-1.423215866088867,-1.297450065612793,-1.161545515060425,-1.052074432373047,-0.9443509578704834,-0.8026421070098877,-0.5817687511444092,-0.3787338733673096,-0.2221298217773438,-0.02885699272155762,0.09599804878234863,0.1700639724731445,0.2538096904754639,0.2416658401489258,0.2389931678771973,0.2459025382995605,0.2402687072753906,0.3380417823791504,0.4152584075927734,0.4031813144683838,0.421595573425293,0.4406368732452393,0.5053889751434326,0.6182503700256348,0.7633936405181885,0.854041576385498,0.7820272445678711,0.6187295913696289,0.5112636089324951,0.5242919921875,0.55755615234375,0.6176161766052246,0.7564282417297363,0.8198273181915283,0.8114373683929443,0.8725309371948242,0.8597457408905029,0.7596540451049805,0.6513667106628418,0.4950118064880371,0.4595744609832764,0.4875850677490234,0.38779616355896,0.3423535823822021,0.4337096214294434,0.5236577987670898,0.6551134586334229,0.8096969127655029,0.7956767082214355,0.7293379306793213,0.7299613952636719,0.6672394275665283,0.6249165534973145,0.6520962715148926,0.6287825107574463,0.6655335426330566,0.7413291931152344,0.8033239841461182,0.8732318878173828,0.9396839141845703,1.117031574249268,1.256712675094604,1.309624910354614,1.348115205764771,1.499508619308472,1.810975074768066,2.108569145202637,2.494475841522217,2.857034206390381,3.0962073802948,3.263113498687744,3.392212390899658,3.454720973968506,3.480929136276245,3.474884033203125,3.42015266418457,3.238273859024048,3.133088350296021,3.178877830505371,3.131217956542969,2.918932437896729,2.762308120727539,2.593863010406494,2.385227680206299,2.171553373336792,1.942960023880005,1.702560186386108,1.338660717010498,0.9587728977203369,0.7179367542266846,0.6122386455535889,0.361170768737793,-0.01457929611206055,-0.4748260974884033,-0.9650802612304688,-1.31438136100769,-1.566562652587891,-1.76862359046936,-1.874247789382935,-1.816998720169067,-1.716601848602295,-1.680991649627686,-1.60942554473877,-1.496524810791016,-1.366283893585205,-1.231327056884766,-1.04883074760437,-0.8176052570343018,-0.5497479438781738,-0.2654600143432617,0.01801252365112305,0.2591931819915771,0.3105032444000244,0.2218711376190186,0.09151458740234375,-0.1040148735046387,-0.249638557434082,-0.2167367935180664,-0.1772308349609375,-0.2163589000701904,-0.2909278869628906,-0.3644955158233643,-0.4491174221038818,-0.5583477020263672,-0.6244957447052002,-0.5979573726654053,-0.4192209243774414,-0.2542722225189209,-0.2379751205444336,-0.2340912818908691,-0.2221512794494629,-0.248788595199585,-0.199272632598877,-0.1899278163909912,-0.3406691551208496,-0.481792688369751,-0.5271482467651367,-0.4902887344360352,-0.3707242012023926,-0.3300833702087402,-0.4367828369140625,-0.4760634899139404,-0.3965640068054199,-0.3271925449371338,-0.1926231384277344,-0.01885533332824707,0.01806378364562988,-0.05341649055480957,-0.1575553417205811,-0.2136123180389404,-0.3912675380706787,-0.6975030899047852,-0.7650613784790039,-0.4822957515716553,-0.3302681446075439,-0.5109190940856934,-0.6848299503326416,-0.6899845600128174,-0.5761826038360596,-0.611107349395752,-0.7818770408630371,-0.8973598480224609,-1.058797836303711,-1.278731822967529,-1.41216516494751,-1.384785175323486,-1.360942125320435,-1.413053274154663,-1.530742645263672,-1.56122088432312,-1.504285335540771,-1.584302186965942,-1.642732620239258,-1.629438400268555,-1.712117195129395,-1.74268364906311,-1.677377223968506,-1.595480442047119,-1.489144563674927,-1.443494558334351,-1.393929719924927,-1.210218667984009,-1.052407026290894,-1.091121435165405,-1.299407482147217,-1.440845727920532,-1.338832378387451,-1.156020164489746,-1.122804880142212,-1.142500638961792,-1.11528754234314,-1.008278131484985,-0.9026110172271729,-0.9616291522979736,-0.9786117076873779,-0.7748246192932129,-0.5167257785797119,-0.46844482421875,-0.6165587902069092,-0.7926547527313232,-0.9639084339141846,-1.047723293304443,-1.009218692779541,-0.917809009552002,-0.8708417415618896,-0.8872103691101074,-0.8913898468017578,-0.8855783939361572,-0.8782219886779785,-0.8984065055847168,-0.9293043613433838,-1.058690547943115,-1.154532432556152,-1.031551361083984,-0.91560959815979,-0.9063851833343506,-0.8890783786773682,-0.831153392791748,-0.8416080474853516,-0.8511030673980713,-0.779041051864624,-0.6666660308837891,-0.5895781517028809,-0.5940747261047363,-0.5797994136810303,-0.4981756210327148,-0.4350733757019043,-0.4142701625823975,-0.3621745109558105,-0.3051984310150146,-0.2596688270568848,-0.236210823059082,-0.2194595336914062,-0.1725387573242188,-0.1276051998138428,-0.04096150398254395,0.1494860649108887,0.2316796779632568,0.07210135459899902,0.008050203323364258,0.1976346969604492,0.3328466415405273,0.4450833797454834,0.5434989929199219,0.6708061695098877,0.8158493041992188,0.9288227558135986,1.078313589096069,1.201316118240356,1.274024248123169,1.37363076210022,1.562790870666504,1.667014360427856,1.681158542633057,1.858980655670166,2.121831178665161,2.224857807159424,2.390062808990479,2.657380104064941,2.661898136138916,2.646026611328125,2.750849723815918,2.891756296157837,3.105719089508057,3.25596809387207,3.224297761917114,3.214211463928223,3.315558433532715,3.412705659866333,3.367072343826294,3.158210515975952,2.942392826080322,2.854969501495361,2.837010622024536,2.766704559326172,2.707304954528809,2.560842037200928,2.344284057617188,2.26195216178894,2.188043594360352,2.043408155441284,1.979066133499146,1.942294836044312,1.890406608581543,1.7699134349823,1.681160926818848,1.509568691253662,1.259539127349854,1.229293346405029,1.382795572280884,1.463915109634399,1.438838243484497,1.452494859695435,1.39579176902771,1.311559677124023,1.30772590637207,1.243085861206055,1.184530258178711,1.214908361434937,1.292988061904907,1.357418298721313,1.401783227920532,1.430366039276123,1.373587846755981,1.402522325515747,1.419658660888672,1.362437009811401,1.307128667831421,1.287411451339722,1.309574842453003,1.246895790100098,1.103744506835938,1.024869680404663,0.9746134281158447,0.9212172031402588,0.895850658416748,0.8094298839569092,0.637814998626709,0.4558897018432617,0.2113914489746094,-0.1398336887359619,-0.5106651782989502,-0.8132970333099365,-1.04758620262146,-1.235439777374268,-1.409813165664673,-1.574903726577759,-1.736882925033569,-2.003844976425171,-2.299402952194214,-2.488102912902832,-2.609386444091797,-2.653820514678955,-2.634155750274658,-2.605712413787842,-2.59640097618103,-2.656036615371704,-2.752161026000977,-2.798786163330078,-2.779507637023926,-2.716776132583618,-2.587072849273682,-2.51370906829834,-2.490401268005371,-2.382351160049438,-2.2475266456604,-2.144734859466553,-1.983228921890259,-1.8515944480896,-1.804776191711426,-1.801751852035522,-1.840747594833374,-1.897553205490112,-1.881076097488403,-1.731600761413574,-1.460956335067749,-1.09714150428772,-0.780874490737915,-0.6580007076263428,-0.6206166744232178,-0.5932044982910156,-0.6008803844451904,-0.7301676273345947,-0.8229672908782959,-0.7741737365722656,-0.7609021663665771,-0.7270801067352295,-0.6614255905151367,-0.6601631641387939,-0.6770944595336914,-0.7106637954711914,-0.7101094722747803,-0.6360507011413574,-0.583575963973999,-0.449066162109375,-0.3308773040771484,-0.3021657466888428,-0.2390241622924805,-0.174109935760498,-0.09086251258850098,0.168452262878418,0.4388618469238281,0.6434953212738037,0.7729482650756836,0.8181953430175781,0.84159255027771,0.9061217308044434,1.020642518997192,1.08228325843811,1.082969903945923,1.076508760452271,1.056810617446899,1.010618209838867,0.9077835083007812,0.7446372509002686,0.6686985492706299,0.63468337059021,0.6048369407653809,0.513763427734375,0.3123593330383301,0.1562345027923584,0.1032114028930664,0.1007735729217529,0.1714766025543213,0.3593993186950684,0.5257570743560791,0.5739665031433105,0.6100726127624512,0.5845916271209717,0.4596340656280518,0.3748905658721924,0.3382992744445801,0.363461971282959,0.4537630081176758,0.5421864986419678,0.5659019947052002,0.5508339405059814,0.4782724380493164,0.4560947418212891,0.4050207138061523,0.1984834671020508,0.06319880485534668,0.1101934909820557,0.2340590953826904,0.3948092460632324,0.5677962303161621,0.5062615871429443,0.2793920040130615,0.212472677230835,0.2631175518035889,0.2149355411529541,0.06804823875427246,-0.05916476249694824,-0.1584124565124512,-0.1879477500915527,-0.1788651943206787,-0.1012158393859863,-0.04653453826904297,-0.03057599067687988,0.05697011947631836,0.08022785186767578,-0.09201645851135254,-0.3255999088287354,-0.3940093517303467,-0.2934134006500244,-0.2991330623626709,-0.5056297779083252,-0.5620622634887695,-0.6341767311096191,-0.8639311790466309,-1.019481420516968,-1.002053022384644,-0.9749341011047363,-0.970454216003418,-0.9888613224029541,-1.043740510940552,-0.9836947917938232,-0.7992768287658691,-0.7357227802276611,-0.6737875938415527,-0.7001388072967529,-0.8997654914855957,-0.9240877628326416,-0.7949841022491455,-0.8211863040924072,-0.8412909507751465,-0.7735705375671387,-0.7314300537109375,-0.6199657917022705,-0.3720307350158691,-0.1864242553710938,-0.1121199131011963,-0.01238107681274414,0.02392292022705078,0.0587010383605957,0.03510117530822754,-0.1739954948425293,-0.2551484107971191,-0.09764432907104492,0.1723766326904297,0.5062496662139893,0.6339013576507568,0.4244339466094971,0.07423996925354004,0.04688143730163574,0.2663683891296387,0.3418385982513428,0.4020226001739502,0.3758001327514648,0.2846086025238037,0.4332280158996582,0.5367195606231689,0.3765296936035156,0.3312480449676514,0.5132114887237549,0.7591462135314941,0.8115708827972412,0.5636537075042725,0.4594480991363525,0.4332458972930908,0.2191925048828125,0.02207159996032715,-0.01002907752990723,-0.09929060935974121,-0.33791184425354,-0.3361570835113525,-0.2471315860748291,-0.2124226093292236,0.03450751304626465,0.1865541934967041,0.1658093929290771,0.09915471076965332,0.143359899520874,0.3471970558166504,0.4665911197662354,0.4908168315887451,0.5970120429992676,0.6749773025512695,0.8568882942199707,1.16341233253479,1.372849941253662,1.458959579467773,1.364295482635498,1.095510721206665,0.8977890014648438,0.9874808788299561,0.9665846824645996,0.669480562210083,0.6377220153808594,0.7223045825958252,0.5257511138916016,0.2293264865875244,0.1719856262207031,0.1861178874969482,-0.005478858947753906,-0.0006330013275146484,0.2091872692108154,0.1909410953521729,0.05065798759460449,-0.008691549301147461,0.0377202033996582,0.1754021644592285,0.1893472671508789,0.1719093322753906,0.3086209297180176,0.07381916046142578,-0.4446113109588623,-0.521237850189209,-0.4765141010284424,-0.7670938968658447,-0.7936215400695801,-0.2052187919616699,0.1399087905883789,0.06818771362304688,-0.1602888107299805,-0.3015613555908203,-0.2704179286956787,-0.4213714599609375,-0.5057263374328613,-0.5764901638031006,-0.5847275257110596,-0.514366626739502,-0.2365291118621826,-0.01394867897033691,-0.116957426071167,-0.2094483375549316,0.0127100944519043,-0.02421140670776367,-0.5310690402984619,-0.7314121723175049,-0.6666886806488037,-0.8010244369506836,-1.04988694190979,-1.183551549911499,-1.026512384414673,-0.7792067527770996,-0.581812858581543,-0.4717004299163818,-0.5923891067504883,-0.8760130405426025,-0.7926976680755615,-0.9129774570465088,-1.421512365341187,-1.544156074523926,-1.436128616333008,-1.522579193115234,-1.545258760452271,-1.662261486053467,-1.691857576370239,-1.245440244674683,-0.9255313873291016,-1.007885932922363,-0.9039533138275146,-1.017820835113525,-1.475965976715088,-1.570278406143188,-0.9834253787994385,-0.3219759464263916,-0.1610326766967773,-0.3967797756195068,-0.4816901683807373,-0.05638599395751953,0.3921079635620117,0.3182899951934814,-0.1949226856231689,-0.6771492958068848,-0.757901668548584,-0.7650625705718994,-0.7562148571014404,-0.4048669338226318,-0.01717090606689453,0.3115880489349365,0.4704821109771729,0.1215362548828125,-0.5513393878936768,-0.734100341796875,-0.5631053447723389,-0.703660249710083,-1.002389192581177,-0.9452784061431885,-0.4953396320343018,-0.291363000869751,-0.2868998050689697,-0.1633870601654053,0.04782438278198242,-0.06267905235290527,0.1418209075927734,0.8610177040100098,1.228396892547607,1.216181516647339,1.454737186431885,1.707649230957031,1.458468437194824,1.220841407775879,1.117745637893677,0.8672153949737549,0.4910051822662354,0.44242262840271,1.162104606628418,2.394622564315796,3.531383275985718,4.024229049682617,3.945260047912598,4.17140007019043,4.111511707305908,2.842699289321899,1.522808074951172,0.4342806339263916,-1.057206392288208,-1.873294115066528,-2.206690311431885,-2.839078903198242,-3.271774053573608,-2.54641056060791,-1.437715291976929,-1.322110891342163,-1.746270656585693,-2.086853981018066,-2.17862606048584,-2.01116681098938,-1.157733201980591,-0.3451848030090332,-0.1681852340698242,-0.2767074108123779,-0.2782583236694336,-0.1837587356567383,-0.112459659576416,0.02347826957702637,0.0754857063293457,0.04229068756103516,0.002086162567138672,0.03107190132141113,0.02832889556884766,-0.04492759704589844,0.009400844573974609,0.2437186241149902,0.3207695484161377,0.1608479022979736,-0.1225030422210693,-0.3972089290618896,-0.4598593711853027,-0.3287231922149658,-0.1223266124725342,0.02052068710327148,0.01408219337463379,-0.07917404174804688,-0.1681649684906006,-0.3921294212341309,-0.5758774280548096,-0.3670358657836914,0.008803606033325195,0.1632452011108398,0.02868056297302246,-0.2271187305450439,-0.3444004058837891,-0.3392481803894043,-0.3337311744689941,-0.3628027439117432,-0.4110980033874512,-0.3817319869995117,-0.3584468364715576,-0.4410934448242188,-0.5292093753814697,-0.5431497097015381,-0.5274403095245361,-0.4696559906005859,-0.4164493083953857,-0.4432356357574463,-0.5425691604614258,-0.6438255310058594,-0.5976223945617676,-0.4780542850494385,-0.3555846214294434,-0.3043520450592041,-0.4687261581420898,-0.6154799461364746,-0.6152427196502686,-0.6431329250335693,-0.6577825546264648,-0.6235051155090332,-0.6070804595947266,-0.5119764804840088,-0.40749192237854,-0.3402769565582275,-0.2825725078582764,-0.2904438972473145,-0.3137528896331787,-0.2926898002624512,-0.2970826625823975,-0.2576589584350586,-0.2457404136657715,-0.3407943248748779,-0.2721178531646729,-0.07873058319091797,0.0007474422454833984,-0.06319165229797363,-0.2547538280487061,-0.4103004932403564,-0.3551197052001953,-0.2924239635467529,-0.2710402011871338,-0.2213203907012939,-0.1962471008300781,-0.2185392379760742,-0.217825174331665,-0.2499091625213623,-0.3439247608184814,-0.3768789768218994,-0.3460252285003662,-0.3415155410766602,-0.3510630130767822,-0.3546953201293945,-0.4507362842559814,-0.4999113082885742,-0.4676306247711182,-0.4590153694152832,-0.3721976280212402,-0.2583110332489014,-0.302354097366333,-0.4409253597259521,-0.471501350402832,-0.4121959209442139,-0.4319906234741211,-0.4662346839904785,-0.4282057285308838,-0.4658782482147217,-0.530550479888916,-0.501333475112915,-0.6014633178710938,-0.7806742191314697,-0.8815371990203857,-0.9408879280090332,-0.9354650974273682,-0.9310281276702881,-0.937727689743042,-0.9358406066894531,-0.9091746807098389,-0.8411884307861328,-0.7559382915496826,-0.6760585308074951,-0.662463903427124,-0.7845973968505859,-0.9455490112304688,-1.007606983184814,-1.036455631256104,-1.038354635238647,-1.02790355682373,-1.064707040786743,-1.019836664199829,-0.8096027374267578,-0.7179415225982666,-0.7337296009063721,-0.6839644908905029,-0.6764435768127441,-0.6831073760986328,-0.6685209274291992,-0.7229030132293701,-0.835566520690918,-0.8448255062103271,-0.742185115814209,-0.6861579418182373,-0.6642842292785645,-0.6003987789154053,-0.561373233795166,-0.5950415134429932,-0.6330859661102295,-0.6986629962921143,-0.7711529731750488,-0.8414089679718018,-0.9295380115509033,-1.031296253204346,-1.114559173583984,-1.161355972290039,-1.21103048324585,-1.198848485946655,-1.126272678375244,-1.080514192581177,-1.025208234786987,-0.8958601951599121,-0.807335376739502,-0.8135771751403809,-0.8520376682281494,-0.909003]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>AR15</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>200</value></param>
<param><key>ymin</key><value>-200</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"direct audio"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
