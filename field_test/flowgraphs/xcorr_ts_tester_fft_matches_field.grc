<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xcorr_tester</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_mic_offset</value></param>
<param><key>value</key><value>1024*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d1</value></param>
<param><key>value</key><value>-64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d2</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d3</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mic_distance</value></param>
<param><key>value</key><value>.498</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>astra_xcorr_ts_ff</key>
<param><key>id</key><value>astra_xcorr_ts_ff_0</value></param>
<param><key>ip_address</key><value>0.0.0.0</value></param>
<param><key>center_mic_offset</key><value>center_mic_offset</value></param>
<param><key>mic_distance</key><value>mic_distance</value></param>
<param><key>node_number</key><value>1</value></param>
<param><key>port_num</key><value>5555</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_window</key><value>15000</value></param>
<param><key>test_number</key><value>office.testing.09.23.16</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>plughw:2,0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>d2+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>d3+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>delay</key><value>d1+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/ben/Desktop/senior_design/field_test/audio_recordings/AK47.50m</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>threshold</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>threshold</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[-0.1175010204315186,-0.112684965133667,-0.05685567855834961,0.03050684928894043,0.11588454246521,0.1792371273040771,0.208200216293335,0.2061057090759277,0.1791131496429443,0.1310741901397705,0.07289648056030273,0.02830028533935547,0.01271724700927734,0.03566622734069824,0.08478164672851562,0.1371872425079346,0.1986539363861084,0.232703685760498,0.1844263076782227,0.1080405712127686,0.09552717208862305,0.1225090026855469,0.1006948947906494,0.03095626831054688,-0.0233769416809082,-0.05010485649108887,-0.06756305694580078,-0.08359313011169434,-0.0980377197265625,-0.1156151294708252,-0.1226711273193359,-0.1454997062683105,-0.2033483982086182,-0.2282977104187012,-0.1657021045684814,-0.05494356155395508,0.04375815391540527,0.1442968845367432,0.2686774730682373,0.3622674942016602,0.3958940505981445,0.4180943965911865,0.4453599452972412,0.4319322109222412,0.38199782371521,0.3409838676452637,0.3001832962036133,0.2202773094177246,0.09765625,-0.04112124443054199,-0.1586520671844482,-0.2225899696350098,-0.2229034900665283,-0.1787936687469482,-0.107804536819458,-0.02481460571289062,0.04689216613769531,0.08816003799438477,0.09967803955078125,0.1028716564178467,0.0898444652557373,0.03186345100402832,-0.0597071647644043,-0.1258945465087891,-0.1396393775939941,-0.1401197910308838,-0.1422429084777832,-0.1109492778778076,-0.04248976707458496,0.03566622734069824,0.1094579696655273,0.1635515689849854,0.2034187316894531,0.2846574783325195,0.3884756565093994,0.4098868370056152,0.2907276153564453,0.1087760925292969,-0.0345003604888916,-0.1254045963287354,-0.1756346225738525,-0.1901781558990479,-0.1901209354400635,-0.1842367649078369,-0.1684188842773438,-0.1465308666229248,-0.1314258575439453,-0.1276874542236328,-0.1311230659484863,-0.1137387752532959,-0.06949067115783691,-0.05849361419677734,-0.09300470352172852,-0.09666919708251953,-0.06394505500793457,-0.06967067718505859,-0.1297664642333984,-0.1806831359863281,-0.1773273944854736,-0.1369762420654297,-0.1223659515380859,-0.130927562713623,-0.09309649467468262,-0.02178668975830078,0.01806855201721191,0.007634162902832031,-0.03745079040527344,-0.07413744926452637,-0.04602432250976562,0.03366708755493164,0.07630586624145508,0.07469058036804199,0.07571697235107422,0.07775664329528809,0.06156444549560547,0.02298474311828613,-0.03582477569580078,-0.09455442428588867,-0.1370465755462646,-0.1533627510070801,-0.1393342018127441,-0.1288986206054688,-0.1579940319061279,-0.1995432376861572,-0.218040943145752,-0.2248477935791016,-0.2242422103881836,-0.1905333995819092,-0.116875171661377,-0.02172112464904785,0.07452726364135742,0.1581251621246338,0.2215111255645752,0.253758430480957,0.2632665634155273,0.2577924728393555,0.2234840393066406,0.1498234272003174,0.05691409111022949,-0.02976894378662109,-0.09069085121154785,-0.1182734966278076,-0.139462947845459,-0.183335542678833,-0.2145779132843018,-0.2093422412872314,-0.1986455917358398,-0.1863431930541992,-0.1260852813720703,-0.02968311309814453,0.01426100730895996,-0.03236889839172363,-0.1100790500640869,-0.1515340805053711,-0.1650500297546387,-0.1952171325683594,-0.2280509471893311,-0.2312719821929932,-0.2133870124816895,-0.1744997501373291,-0.1181209087371826,-0.06757616996765137,-0.03189563751220703,-0.01008272171020508,0.01695513725280762,0.06394743919372559,0.1220357418060303,0.1758444309234619,0.2238953113555908,0.2543938159942627,0.2661240100860596,0.2531111240386963,0.1827478408813477,0.08185863494873047,0.03677725791931152,0.06176233291625977,0.08429408073425293,0.0815129280090332,0.1145219802856445,0.190269947052002,0.2551901340484619,0.2970075607299805,0.3430306911468506,0.3499555587768555,0.2811026573181152,0.2178502082824707,0.195457935333252,0.1245033740997314,-0.02148151397705078,-0.1611196994781494,-0.2526283264160156,-0.313868522644043,-0.3612077236175537,-0.395883321762085,-0.40435791015625,-0.3763151168823242,-0.3196895122528076,-0.260932445526123,-0.1944220066070557,-0.09044647216796875,0.03501772880554199,0.1441371440887451,0.238652229309082,0.3069198131561279,0.2879762649536133,0.1575160026550293,-0.02066969871520996,-0.1604139804840088,-0.2236199378967285,-0.2198588848114014,-0.185854434967041,-0.1452720165252686,-0.08434414863586426,0.01736283302307129,0.1186013221740723,0.1521766185760498,0.1413393020629883,0.1472580432891846,0.1750397682189941,0.1788425445556641,0.1187741756439209,0.04027605056762695,0.01685857772827148,0.03884196281433105,0.03373503684997559,0.002590417861938477,0.0223851203918457,0.1047801971435547,0.1686215400695801,0.1737463474273682,0.184098482131958,0.2290558815002441,0.2487301826477051,0.2278923988342285,0.2131342887878418,0.2235448360443115,0.2506065368652344,0.2836704254150391,0.30517578125,0.3001141548156738,0.2444088459014893,0.1363754272460938,0.0464320182800293,0.02663254737854004,0.03470301628112793,0.04367709159851074,0.1048266887664795,0.2415823936462402,0.4042196273803711,0.4884254932403564,0.427401065826416,0.296332836151123,0.1895928382873535,0.1050698757171631,0.03422141075134277,-0.004508495330810547,0.004243850708007812,0.05074024200439453,0.08326172828674316,0.06918787956237793,0.05270838737487793,0.07246732711791992,0.09990453720092773,0.1198601722717285,0.1364767551422119,0.1268064975738525,0.08587002754211426,0.04980683326721191,0.0571894645690918,0.09943246841430664,0.09426593780517578,-0.006057024002075195,-0.1396727561950684,-0.2401256561279297,-0.3090798854827881,-0.3492593765258789,-0.363699197769165,-0.3795933723449707,-0.3883671760559082,-0.3674924373626709,-0.3214764595031738,-0.2481579780578613,-0.1649200916290283,-0.1269245147705078,-0.1308155059814453,-0.1006710529327393,-0.04820823669433594,-0.05601644515991211,-0.1236808300018311,-0.1821672916412354,-0.2315902709960938,-0.2924251556396484,-0.3509128093719482,-0.3943884372711182,-0.4152345657348633,-0.4130840301513672,-0.395207405090332,-0.3558731079101562,-0.3010046482086182,-0.2602529525756836,-0.2469801902770996,-0.2525591850280762,-0.2749323844909668,-0.2919149398803711,-0.2719831466674805,-0.2091765403747559,-0.1467239856719971,-0.1230025291442871,-0.09321451187133789,-0.007756948471069336,0.09738564491271973,0.1833665370941162,0.2534794807434082,0.3101015090942383,0.3226256370544434,0.2621829509735107,0.1654565334320068,0.08202552795410156,0.0004827976226806641,-0.1000070571899414,-0.1708316802978516,-0.1743590831756592,-0.1422345638275146,-0.1016426086425781,-0.06088852882385254,-0.02326011657714844,-0.001430511474609375,-0.007150173187255859,-0.01570701599121094,-0.004090070724487305,0.004162788391113281,0.003904104232788086,0.04395246505737305,0.1333975791931152,0.209205150604248,0.2477097511291504,0.2910900115966797,0.3315830230712891,0.3343594074249268,0.3263199329376221,0.320734977722168,0.3019237518310547,0.2695560455322266,0.1978766918182373,0.09335160255432129,0.01008868217468262,-0.03910541534423828,-0.08703351020812988,-0.1311254501342773,-0.1614165306091309,-0.2095448970794678,-0.2709317207336426,-0.2912616729736328,-0.243077278137207,-0.1494526863098145,-0.06304383277893066,0.01607418060302734,0.110015869140625,0.1743388175964355,0.1709282398223877,0.1246082782745361,0.05856156349182129,-0.005449056625366211,-0.0342404842376709,-0.02393722534179688,0.01916885375976562,0.08614540100097656,0.1165318489074707,0.05616426467895508,-0.07161140441894531,-0.2069938182830811,-0.3073155879974365,-0.371391773223877,-0.4111051559448242,-0.421900749206543,-0.3681814670562744,-0.25063157081604,-0.1488173007965088,-0.1119577884674072,-0.1227164268493652,-0.1508903503417969,-0.1827645301818848,-0.210031270980835,-0.2130138874053955,-0.1801717281341553,-0.117267370223999,-0.04510283470153809,0.001401901245117188,0.01736879348754883,0.04398941993713379,0.09097695350646973,0.1225411891937256,0.1156437397003174,0.08652925491333008,0.07522344589233398,0.09042143821716309,0.1027238368988037,0.09597063064575195,0.06520271301269531,0.04351377487182617,0.07135272026062012,0.1081526279449463,0.08533954620361328,0.02680063247680664,0.004001855850219727,0.02565622329711914,0.05738377571105957,0.0852203369140625,0.1121377944946289,0.1681268215179443,0.2427959442138672,0.2728605270385742,0.2260732650756836,0.1360452175140381,0.07320880889892578,0.07213711738586426,0.1035976409912109,0.1189887523651123,0.1215755939483643,0.1654219627380371,0.2367711067199707,0.2469754219055176,0.1888358592987061,0.1137065887451172,0.02322554588317871,-0.06323814392089844,-0.09202241897583008,-0.05000948905944824,0.02769351005554199,0.0970160961151123,0.1249825954437256,0.1070380210876465,0.05547761917114258,0.001786947250366211,-0.02960681915283203,-0.03579258918762207,-0.03415465354919434,-0.02694129943847656,-0.01190662384033203,0.01057744026184082,0.06716132164001465,0.163649320602417,0.2165675163269043,0.1866412162780762,0.1382946968078613,0.1123499870300293,0.1108121871948242,0.1072847843170166,0.1008641719818115,0.1140189170837402,0.1206064224243164,0.07475137710571289,0.009200572967529297,-0.03023982048034668,-0.05309224128723145,-0.07957220077514648,-0.1012051105499268,-0.116807222366333,-0.1286208629608154,-0.1312112808227539,-0.1150965690612793,-0.07149696350097656,-0.009381771087646484,0.05535244941711426,0.1048994064331055,0.1171481609344482,0.07972121238708496,0.01486778259277344,-0.0492393970489502,-0.1197850704193115,-0.1881909370422363,-0.2203178405761719,-0.2095341682434082,-0.1815354824066162,-0.164872407913208,-0.1479482650756836,-0.1043939590454102,-0.04160642623901367,0.01713037490844727,0.08879303932189941,0.1726758480072021,0.2052092552185059,0.1599240303039551,0.09102463722229004,0.05054235458374023,0.04323482513427734,0.04111528396606445,0.01629114151000977,-0.04020571708679199,-0.1189422607421875,-0.2063977718353271,-0.2839291095733643,-0.3213667869567871,-0.298159122467041,-0.227895975112915,-0.1476263999938965,-0.06806850433349609,0.01757621765136719,0.07466793060302734,0.06105780601501465,0.01177430152893066,-0.009081363677978516,-0.004221200942993164,-0.02969861030578613,-0.1006829738616943,-0.1600432395935059,-0.1812398433685303,-0.1916635036468506,-0.1816797256469727,-0.1184713840484619,-0.01150965690612793,0.06970763206481934,0.09864091873168945,0.117563009262085,0.1318764686584473,0.116497278213501,0.07405877113342285,0.009757280349731445,-0.0553584098815918,-0.07468938827514648,-0.04116058349609375,-0.004926919937133789,0.001252889633178711,-0.008758306503295898,-0.01966476440429688,-0.03068685531616211,-0.02909421920776367,0.008957386016845703,0.08220076560974121,0.1742148399353027,0.2623546123504639,0.3111541271209717,0.2840971946716309,0.1956295967102051,0.1123368740081787,0.0739443302154541,0.0494384765625,0.01053094863891602,-0.02238869667053223,-0.02108454704284668,0.008767843246459961,0.02141714096069336,-0.01534819602966309,-0.07140040397644043,-0.0806117057800293,-0.04410386085510254,-0.006889104843139648,0.01937270164489746,0.02853631973266602,0.01284480094909668,-0.01709699630737305,-0.05572915077209473,-0.09846806526184082,-0.1254010200500488,-0.1276624202728271,-0.113532543182373,-0.08739829063415527,-0.04920125007629395,-0.02368927001953125,-0.03682851791381836,-0.06939530372619629,-0.09568572044372559,-0.1260411739349365,-0.1604723930358887,-0.1980030536651611,-0.2478313446044922,-0.3073585033416748,-0.3509604930877686,-0.3549051284790039,-0.3491687774658203,-0.3757214546203613,-0.4059958457946777,-0.3898906707763672,-0.3302228450775146,-0.2660238742828369,-0.2117383480072021,-0.1536953449249268,-0.09277701377868652,-0.04711270332336426,-0.02222180366516113,-0.02530813217163086,-0.06649613380432129,-0.1250135898590088,-0.1576042175292969,-0.1466560363769531,-0.1076185703277588,-0.04652976989746094,0.026092529296875,0.07483124732971191,0.08572220802307129,0.07042884826660156,0.03935456275939941,0.005251169204711914,-0.03048062324523926,-0.06542444229125977,-0.08241534233093262,-0.07556438446044922,-0.06819367408752441,-0.08249998092651367,-0.1187801361083984,-0.1590681076049805,-0.1784121990203857,-0.1877295970916748,-0.1993870735168457,-0.1682937145233154,-0.06796836853027344,0.07396221160888672,0.2058327198028564,0.2857422828674316,0.2981710433959961,0.2729332447052002,0.235668420791626,0.181121826171875,0.1235032081604004,0.09813785552978516,0.07914066314697266,0.03263235092163086,-0.01771211624145508,-0.02917766571044922,-0.01570820808410645,-0.0140690803527832,-0.00124812126159668,0.06861686706542969,0.1621973514556885,0.2054131031036377,0.197824239730835,0.1877522468566895,0.1920151710510254,0.1748430728912354,0.1212596893310547,0.07118940353393555,0.02882122993469238,-0.03960609436035156,-0.1014399528503418,-0.1047956943511963,-0.06634116172790527,0.004098415374755859,0.1301860809326172,0.2654337882995605,0.3252816200256348,0.300213098526001,0.2227175235748291,0.1113176345825195,-0.02550125122070312,-0.1615655422210693,-0.2739083766937256,-0.3531765937805176,-0.3958630561828613,-0.4037868976593018,-0.3737211227416992,-0.3108179569244385,-0.2422749996185303,-0.1999306678771973,-0.1996064186096191,-0.2070319652557373,-0.159909725189209,-0.06285548210144043,0.01863479614257812,0.09341835975646973,0.2088665962219238,0.3181827068328857,0.3492116928100586,0.2951061725616455,0.2142250537872314,0.1606488227844238,0.127565860748291,0.08931756019592285,0.05638957023620605,0.06960272789001465,0.1272737979888916,0.1784801483154297,0.1850700378417969,0.1514685153961182,0.1174259185791016,0.1113510131835938,0.1101469993591309,0.06700277328491211,-0.006598234176635742,-0.04289388656616211,-0.004150867462158203,0.07606744766235352,0.1166355609893799,0.1000487804412842,0.07649779319763184,0.09159326553344727,0.1580297946929932,0.2565872669219971,0.3561532497406006,0.4088938236236572,0.3966093063354492,0.347667932510376,0.2691686153411865,0.185539722442627,0.1403689384460449,0.1408708095550537,0.1680314540863037,0.1660525798797607,0.1089131832122803,0.04812836647033691,-0.007268190383911133,-0.09293079376220703,-0.1698875427246094,-0.1592707633972168,-0.0951385498046875,-0.05818963050842285,-0.02198576927185059,0.07010698318481445,0.1519238948822021,0.1555883884429932,0.1456427574157715,0.177152156829834,0.1871979236602783,0.1462900638580322,0.1358640193939209,0.1938092708587646,0.2270340919494629,0.1996994018554688,0.1738238334655762,0.152360200881958,0.07820606231689453,-0.02240180969238281,-0.07570028305053711,-0.08752942085266113,-0.0831449031829834,-0.04392504692077637,0.02354621887207031,0.05362749099731445,0.02000808715820312,-0.01549243927001953,-0.01400470733642578,-0.01013278961181641,-0.0438845157623291,-0.09058237075805664,-0.09842157363891602,-0.05339503288269043,0.03130912780761719,0.1458215713500977,0.2101242542266846,0.1894521713256836,0.1505100727081299,0.1122653484344482,0.02333641052246094,-0.1019608974456787,-0.2040731906890869,-0.2858471870422363,-0.3503859043121338,-0.3751826286315918,-0.343165397644043,-0.2789556980133057,-0.2351152896881104,-0.2243256568908691,-0.2340924739837646,-0.274803638458252,-0.3248822689056396,-0.3489017486572266,-0.3647994995117188,-0.4121243953704834,-0.483015775680542,-0.5294930934906006,-0.5220663547515869,-0.4834282398223877,-0.4519808292388916,-0.4124832153320312,-0.3512132167816162,-0.2876389026641846,-0.1996314525604248,-0.08980870246887207,-0.004084110260009766,0.01785993576049805,-0.07115721702575684,-0.2478921413421631,-0.4126322269439697,-0.515587329864502,-0.5799949169158936,-0.5981111526489258,-0.5558192729949951,-0.4737591743469238,-0.3880047798156738,-0.3439605236053467,-0.3376662731170654,-0.3352272510528564,-0.3541767597198486,-0.4069554805755615,-0.4458475112915039,-0.4416000843048096,-0.3952372074127197,-0.3137433528900146,-0.2353501319885254,-0.2141904830932617,-0.2669262886047363,-0.3428936004638672,-0.3540444374084473,-0.2904689311981201,-0.2111208438873291,-0.1479899883270264,-0.0683128833770752,0.02706646919250488,0.07442116737365723,0.07276415824890137,0.06900906562805176,0.05353689193725586,0.02429366111755371,0.02832174301147461,0.06304383277893066,0.0558936595916748,0.002384185791015625,-0.009067058563232422,0.04695773124694824,0.09200930595397949,0.1028501987457275,0.1157629489898682,0.1061272621154785,0.09382128715515137,0.1484572887420654,0.2192258834838867,0.2122378349304199,0.1734626293182373,0.1955151557922363,0.2467000484466553,0.268782377243042,0.2802109718322754,0.3028202056884766,0.3073358535766602,0.2674150466918945,0.2275395393371582,0.2302813529968262,0.2493143081665039,0.25870680809021,0.3021121025085449,0.3873586654663086,0.4214012622833252,0.3773212432861328,0.3426527976989746,0.3330159187316895,0.312117338180542,0.2817177772521973,0.2574121952056885,0.2239000797271729,0.1575779914855957,0.09915828704833984,0.0902855396270752,0.09820103645324707,0.1131308078765869,0.1766133308410645,0.2526915073394775,0.2762019634246826,0.281376838684082,0.3006839752197266,0.3009939193725586,0.2687442302703857,0.2515697479248047,0.2872931957244873,0.3519928455352783,0.3819060325622559,0.3348839282989502,0.2343249320983887,0.141674280166626,0.07874846458435059,0.03806471824645996,0.02501964569091797,0.05114912986755371,0.1113426685333252,0.1851952075958252,0.2708399295806885,0.3711843490600586,0.4412961006164551,0.4435145854949951,0.3848052024841309,0.3094518184661865,0.2481484413146973,0.1799225807189941,0.0932610034942627,0.004514455795288086,-0.04850387573242188,-0.04337310791015625,0.01059055328369141,0.08288383483886719,0.1412773132324219,0.162360668182373,0.1401817798614502,0.1214420795440674,0.1269233226776123,0.1160109043121338,0.1066112518310547,0.1356327533721924,0.1644909381866455,0.1513755321502686,0.1234877109527588,0.09986400604248047,0.03819704055786133,-0.03799557685852051,-0.05721211433410645,-0.04202127456665039,-0.06192803382873535,-0.08966207504272461,-0.06973743438720703,-0.02394199371337891,0.008144378662109375,0.004571676254272461,-0.06624937057495117,-0.1796829700469971,-0.2578747272491455,-0.2637612819671631,-0.2447307109832764,-0.2314162254333496,-0.1843953132629395,-0.09456992149353027,-0.02834677696228027,-0.009354352951049805,-0.0006008148193359375,-0.01553535461425781,-0.07680296897888184,-0.1516461372375488,-0.18729567527771,-0.1738178730010986,-0.157245397567749,-0.1773238182067871,-0.2240777015686035,-0.287172794342041,-0.3540170192718506,-0.3634774684906006,-0.310513973236084,-0.2626430988311768,-0.238494873046875,-0.234520435333252,-0.2502667903900146,-0.2566242218017578,-0.2455019950866699,-0.2243030071258545,-0.1943659782409668,-0.1596963405609131,-0.1309692859649658,-0.1130533218383789,-0.08761286735534668,-0.04205822944641113,0.005030632019042969,0.01215815544128418,-0.006225109100341797,-0.01104474067687988,-0.01598596572875977,-0.03812670707702637,-0.05545496940612793,-0.05234837532043457,-0.07161259651184082,-0.1237022876739502,-0.1505577564239502,-0.1261758804321289,-0.05890607833862305,0.02400755882263184,0.07120370864868164,0.07544994354248047,0.07602810859680176,0.1029038429260254,0.1517355442047119,0.1947438716888428,0.2157950401306152,0.2388644218444824,0.2757763862609863,0.2974486351013184,0.2913522720336914,0.2634525299072266,0.2111184597015381,0.1751649379730225,0.1863729953765869,0.2301895618438721,0.2919292449951172,0.3198683261871338,0.2570950984954834,0.1178157329559326,-0.04778742790222168,-0.1870453357696533,-0.2534401416778564,-0.2530372142791748,-0.2274477481842041,-0.1804828643798828,-0.07788419723510742,0.05623459815979004,0.1209235191345215,0.06919264793395996,-0.003618001937866211,-0.02394318580627441,-0.01851916313171387,-0.001088380813598633,0.05992889404296875,0.1385402679443359,0.1529669761657715,0.08622407913208008,0.01183390617370605,-0.02641797065734863,-0.05147099494934082,-0.0716698169708252,-0.06686091423034668,-0.04338383674621582,-0.0401616096496582,-0.05524396896362305,-0.083770751953125,-0.1317214965820312,-0.2043259143829346,-0.2689504623413086,-0.2635073661804199,-0.1917695999145508,-0.1235413551330566,-0.08225321769714355,-0.04172325134277344,-0.01293420791625977,-0.02542376518249512,-0.06865501403808594,-0.07623195648193359,-0.009877681732177734,0.06994843482971191,0.1161038875579834,0.1529347896575928,0.2028298377990723,0.2447736263275146,0.2650904655456543,0.2692067623138428,0.243990421295166,0.1841366291046143,0.1106452941894531,0.03436565399169922,-0.05739212036132812,-0.1642954349517822,-0.2375459671020508,-0.2442383766174316,-0.2152740955352783,-0.186992883682251,-0.1681315898895264,-0.1675403118133545,-0.181419849395752,-0.175468921661377,-0.157470703125,-0.1311087608337402,-0.06112456321716309,0.03220915794372559,0.1127731800079346,0.2037131786346436,0.3017306327819824,0.3162646293640137,0.1938879489898682,0.01687169075012207,-0.1099443435668945,-0.1518905162811279,-0.1476383209228516,-0.14396071434021,-0.1586103439331055,-0.1689064502716064,-0.1225507259368896,-0.01530766487121582,0.05663394927978516,0.01981616020202637,-0.05607962608337402,-0.103611946105957,-0.1547777652740479,-0.2229535579681396,-0.2808141708374023,-0.3133559226989746,-0.3108751773834229,-0.2764904499053955,-0.2161145210266113,-0.1367449760437012,-0.05458474159240723,0.02862334251403809,0.1060914993286133,0.158919095993042,0.1630198955535889,0.111849308013916,0.03441452980041504,-0.03862619400024414,-0.09842514991760254,-0.1492679119110107,-0.1904845237731934,-0.2029800415039062,-0.166466236114502,-0.09954690933227539,-0.06570935249328613,-0.05900263786315918,-0.0305640697479248,-0.005679130554199219,-0.03125667572021484,-0.05852937698364258,-0.0181114673614502,0.04884123802185059,0.09446620941162109,0.129859447479248,0.1302850246429443,0.05849719047546387,-0.02373814582824707,-0.04162907600402832,-0.02216577529907227,-0.007503032684326172,0.006887912750244141,0.06629586219787598,0.1656055450439453,0.2333593368530273,0.2149629592895508,0.1099121570587158,-0.02247214317321777,-0.1151549816131592,-0.1434910297393799,-0.1426029205322266,-0.1326334476470947,-0.08227944374084473,0.04635334014892578,0.2118325233459473,0.3085458278656006,0.3087151050567627,0.2656972408294678,0.195387601852417,0.09920001029968262,0.03181695938110352,0.0430750846862793,0.08651256561279297,0.1200211048126221,0.1824080944061279,0.2680385112762451,0.3099417686462402,0.2831757068634033,0.1893079280853271,0.06256699562072754,-0.03788948059082031,-0.07622003555297852,-0.0697779655456543,-0.07667422294616699,-0.1147091388702393,-0.1321196556091309,-0.0850379467010498,-0.001299381256103516,0.06652235984802246,0.08529186248779297,0.05260109901428223,0.000476837158203125,-0.03391027450561523,-0.0261390209197998,0.02710342407226562,0.1051104068756104,0.1665806770324707,0.1977980136871338,0.2129995822906494,0.200660228729248,0.1815116405487061,0.1959097385406494,0.1942551136016846,0.1479780673980713,0.1028740406036377,0.04757404327392578,-0.04785656929016113,-0.1208209991455078,-0.1192986965179443,-0.09343385696411133,-0.1015424728393555,-0.1346313953399658,-0.1704525947570801,-0.200197696685791,-0.2178454399108887,-0.218963623046875,-0.1711809635162354,-0.0686347484588623,0.04148006439208984,0.1365351676940918,0.1845669746398926,0.1407468318939209,0.05088210105895996,-0.0279843807220459,-0.1029872894287109,-0.1517057418823242,-0.1303303241729736,-0.04369378089904785,0.07672429084777832,0.1965761184692383,0.3013443946838379,0.4027187824249268,0.4854977130889893,0.5022132396697998,0.4618573188781738,0.409243106842041,0.3334999084472656,0.2400743961334229,0.1842367649078369,0.1818406581878662,0.2178680896759033,0.2590703964233398,0.2526545524597168,0.2015185356140137,0.159451961517334,0.1464688777923584,0.1630055904388428,0.2059304714202881,0.2586138248443604,0.3248882293701172,0.4056477546691895,0.4730892181396484,0.5246472358703613,0.5614447593688965,0.5139827728271484,0.361168384552002,0.1998066902160645,0.08756160736083984,0.02858161926269531,0.009195804595947266,0.01264572143554688,0.04803776741027832,0.09403824806213379,0.1204347610473633,0.137336254119873,0.1515293121337891,0.1270890235900879,0.05046248435974121,-0.03418087959289551,-0.07929682731628418,-0.08666753768920898,-0.09531855583190918,-0.1059079170227051,-0.1115036010742188,-0.1343786716461182,-0.1876449584960938,-0.2346992492675781,-0.2556204795837402,-0.287775993347168,-0.3342854976654053,-0.3597044944763184,-0.3630959987640381,-0.3330338001251221,-0.2475953102111816,-0.1771485805511475,-0.1966488361358643,-0.2627730369567871,-0.2947497367858887,-0.2940917015075684,-0.2888572216033936,-0.2314281463623047,-0.08708357810974121,0.03229737281799316,0.04084944725036621,0.008813142776489258,-0.01005649566650391,-0.04073023796081543,-0.08108258247375488,-0.1128172874450684,-0.1450669765472412,-0.176851749420166,-0.1815581321716309,-0.1395916938781738,-0.07781744003295898,-0.03788232803344727,-0.03242611885070801,-0.04492044448852539,-0.06455659866333008,-0.09151697158813477,-0.1115667819976807,-0.1299083232879639,-0.1660811901092529,-0.1929247379302979,-0.1626038551330566,-0.0865328311920166,0.0008988380432128906,0.1017975807189941,0.1870596408843994,0.2003669738769531,0.1619923114776611,0.1145684719085693,0.05181670188903809,-0.04201889038085938,-0.1568567752838135,-0.2613687515258789,-0.3054296970367432,-0.2840805053710938,-0.2483034133911133,-0.213620662689209,-0.1572191715240479,-0.1114809513092041,-0.09742379188537598,-0.08255839347839355,-0.07645726203918457,-0.1011765003204346,-0.1185059547424316,-0.09541511535644531,-0.06150364875793457,-0.02314925193786621,0.03918170928955078,0.06407737731933594,-0.0144803524017334,-0.131223201751709,-0.2011489868164062,-0.2247142791748047,-0.2288353443145752,-0.2043163776397705,-0.1391887664794922,-0.07272601127624512,-0.04540324211120605,-0.04652619361877441,-0.06318449974060059,-0.09860873222351074,-0.1641392707824707,-0.2477586269378662,-0.307849645614624,-0.2933037281036377,-0.1966536045074463,-0.09199261665344238,-0.02813577651977539,0.004721879959106445,-0.01079320907592773,-0.07665872573852539,-0.1481831073760986,-0.1900303363800049,-0.2009308338165283,-0.1864063739776611,-0.1452887058258057,-0.06980419158935547,0.03795742988586426,0.1548123359680176,0.2387094497680664,0.2663612365722656,0.2529013156890869,0.2380180358886719,0.2217352390289307,0.1787984371185303,0.1647651195526123,0.2371513843536377,0.3666889667510986,0.4864954948425293,0.5630803108215332,0.5901765823364258,0.5326831340789795,0.3922092914581299,0.254218578338623,0.1635909080505371,0.09670853614807129,0.0743710994720459,0.1179337501525879,0.1658940315246582,0.1787078380584717,0.1690208911895752,0.1423060894012451,0.118640661239624,0.1447451114654541,0.1796150207519531,0.1398015022277832,0.06521821022033691,0.0388491153717041,0.06016016006469727,0.08234024047851562,0.09239554405212402,0.1421165466308594,0.2488744258880615,0.3330588340759277,0.3246808052062988,0.2754712104797363,0.2453339099884033,0.2136409282684326,0.1615273952484131,0.1173889636993408,0.0872802734375,0.04158139228820801,0.00203251838684082,-0.002319812774658203,0.002033710479736328,0.009173154830932617,0.04920601844787598,0.1173758506774902,0.1733279228210449,0.1968324184417725,0.2122759819030762,0.2349698543548584,0.2673804759979248,0.294719934463501,0.2892887592315674,0.2643072605133057,0.2194392681121826,0.1128244400024414,-0.03125667572021484,-0.1349163055419922,-0.1894593238830566,-0.2387070655822754,-0.2661120891571045,-0.2399778366088867,-0.2142202854156494,-0.2216053009033203,-0.2133727073669434,-0.1785957813262939,-0.1595664024353027,-0.1830542087554932,-0.2178323268890381,-0.2165436744689941,-0.1761603355407715,-0.1143550872802734,-0.05699515342712402,-0.008053779602050781,0.0322878360748291,0.03106236457824707,-0.04725456237792969,-0.1684486865997314,-0.2814841270446777,-0.3521013259887695,-0.3526532649993896,-0.3004062175750732,-0.2344000339508057,-0.197833776473999,-0.1797091960906982,-0.1438164710998535,-0.1052796840667725,-0.09357810020446777,-0.08580207824707031,-0.05246281623840332,-0.01981258392333984,-0.02868771553039551,-0.05096077919006348,-0.05183815956115723,-0.04701375961303711,-0.03752589225769043,-0.01561999320983887,-0.001024007797241211,-0.003741979598999023,0.02145648002624512,0.09094953536987305,0.1628696918487549,0.2363729476928711,0.3215515613555908,0.3735411167144775,0.3643572330474854,0.3009295463562012,0.1851749420166016,0.06520748138427734,0.004333257675170898,-0.01345515251159668,-0.03274202346801758,-0.04636049270629883,-0.03069877624511719,-0.001883506774902344,-0.006480216979980469,-0.05974888801574707,-0.09241104125976562,-0.06356239318847656,-0.02395033836364746,-0.009101629257202148,0.01431107521057129,0.07912516593933105,0.1757729053497314,0.2614414691925049,0.3043735027313232,0.29937744140625,0.2516555786132812,0.201183557510376,0.1610910892486572,0.124737024307251,0.1077425479888916,0.1046848297119141,0.08582949638366699,0.04383325576782227,0.004541873931884766,-0.03420829772949219,-0.1049399375915527,-0.1568806171417236,-0.1124167442321777,0.01456499099731445,0.1319491863250732,0.1967966556549072,0.2173912525177002,0.1877462863922119,0.1116645336151123,0.05064606666564941,0.05985498428344727,0.09207725524902344,0.1119637489318848,0.1486015319824219,0.1679050922393799,0.1270437240600586,0.07365584373474121,0.04473090171813965,0.02164006233215332,-0.01129508018493652,-0.0490117073059082,-0.0685429573059082,-0.06768345832824707,-0.07829785346984863,-0.08416533470153809,-0.07157087326049805,-0.08303165435791016,-0.09925603866577148,-0.0603330135345459,0.002263784408569336,-0.001835823059082031,-0.05366683006286621,-0.08118629455566406,-0.1070702075958252,-0.1730751991271973,-0.2540194988250732,-0.2943670749664307,-0.2835738658905029,-0.2498388290405273,-0.2151083946228027,-0.1778388023376465,-0.1275730133056641,-0.09077191352844238,-0.1039183139801025,-0.1589405536651611,-0.2362740039825439,-0.3005242347717285,-0.3300964832305908,-0.3462958335876465,-0.3334760665893555,-0.2786421775817871,-0.2261865139007568,-0.2154076099395752,-0.2032136917114258,-0.1573038101196289,-0.1136183738708496,-0.1196432113647461,-0.1429951190948486,-0.1058101654052734,-0.008186101913452148,0.06311297416687012,0.07417201995849609,0.03919482231140137,-0.02068161964416504,-0.08726358413696289,-0.1394951343536377,-0.1555633544921875,-0.1411139965057373,-0.1215183734893799,-0.1105904579162598,-0.07861733436584473,-0.02024650573730469,0.01346111297607422,-0.0006330013275146484,-0.04138588905334473,-0.08236527442932129,-0.118335485458374,-0.1561582088470459,-0.141061544418335,-0.04564404487609863,0.05019068717956543,0.08469700813293457,0.104067325592041,0.1542699337005615,0.1869297027587891,0.1427304744720459,0.06561994552612305,0.02743840217590332,0.02972602844238281,0.03830790519714355,0.05258440971374512,0.09672880172729492,0.1577520370483398,0.1947295665740967,0.1844632625579834,0.128406286239624,0.07706046104431152,0.0971686840057373,0.1601564884185791,0.1800227165222168,0.1498770713806152,0.1359641551971436,0.1473438739776611,0.1636624336242676,0.1658999919891357,0.135120153427124,0.09498834609985352,0.07924199104309082,0.05775690078735352,-0.003648996353149414,-0.06508946418762207,-0.07723569869995117,-0.07055997848510742,-0.09589433670043945,-0.1113712787628174,-0.05445599555969238,0.04394054412841797,0.09528160095214844,0.1126706600189209,0.1806449890136719,0.2615690231323242,0.2318179607391357,0.1243031024932861,0.09052157402038574,0.1610863208770752,0.2074086666107178,0.1889228820800781,0.1724767684936523,0.1757383346557617,0.2119815349578857,0.3310072422027588,0.4892516136169434,0.5473864078521729,0.4688429832458496,0.3421986103057861,0.2497375011444092,0.198293924331665,0.1504421234130859,0.1163458824157715,0.1233935356140137,0.1231682300567627,0.08655786514282227,0.03033757209777832,-0.0214838981628418,-0.03681182861328125,0.01479625701904297,0.09407758712768555,0.1581013202667236,0.2276086807250977,0.3005778789520264,0.3455078601837158,0.326000452041626,0.2605891227722168,0.2050447463989258,0.1549780368804932,0.08274078369140625,0.0006806850433349609,-0.0309443473815918,-0.00603795051574707,0.01180052757263184,-1.430511474609375e-05,-0.02101302146911621,-0.05259156227111816,-0.07101655006408691,-0.02792835235595703,0.05325198173522949,0.1184868812561035,0.1908349990844727,0.2633583545684814,0.2571630477905273,0.1785683631896973,0.08866429328918457,-0.02988338470458984,-0.19173264503479,-0.3116440773010254,-0.3297340869903564,-0.2883732318878174,-0.2452671527862549,-0.1978659629821777,-0.126502513885498,-0.0887596607208252,-0.1305902004241943,-0.2050697803497314,-0.2601099014282227,-0.2880823612213135,-0.2977800369262695,-0.275568962097168,-0.2082836627960205,-0.1344823837280273,-0.1036810874938965,-0.114898681640625,-0.1716077327728271,-0.2762317657470703,-0.3568494319915771,-0.357363224029541,-0.2997970581054688,-0.2113699913024902,-0.06786942481994629,0.1092898845672607,0.2017056941986084,0.1833069324493408,0.1138544082641602,0.03813743591308594,0.02342581748962402,0.08217692375183105,0.08741497993469238,0.005662441253662109,-0.02293825149536133,0.0684821605682373,0.144580602645874,0.1109921932220459,0.0813138484954834,0.1497888565063477,0.2042603492736816,0.1442849636077881,0.06948113441467285,0.03364682197570801,-0.05588531494140625,-0.2029049396514893,-0.2861368656158447,-0.2823400497436523,-0.2681350708007812,-0.2753198146820068,-0.2770590782165527,-0.2855634689331055,-0.3038811683654785,-0.2928948402404785,-0.2617120742797852,-0.2720999717712402,-0.3050220012664795,-0.2687501907348633,-0.1616215705871582,-0.05441427230834961,0.03194928169250488,0.09698390960693359,0.11832594871521,0.0787961483001709,-0.01080989837646484,-0.09805440902709961,-0.1147174835205078,-0.1032984256744385,-0.1625311374664307,-0.2570044994354248,-0.3059566020965576,-0.3098213672637939,-0.3162896633148193,-0.334172248840332,-0.3244304656982422,-0.2700984477996826,-0.2240002155303955,-0.2115845680236816,-0.1613974571228027,-0.08041501045227051,-0.05828619003295898,-0.08443713188171387,-0.1039063930511475,-0.1182591915130615,-0.1155686378479004,-0.06165981292724609,0.03081440925598145,0.1230347156524658,0.1826047897338867,0.2129220962524414,0.2689540386199951,0.3587079048156738,0.4231119155883789,0.4120039939880371,0.321042537689209,0.2187275886535645,0.1505410671234131,0.07004499435424805,-0.04342794418334961,-0.1173841953277588,-0.08522510528564453,0.04542231559753418,0.1823806762695312,0.2741467952728271,0.3735637664794922,0.4845261573791504,0.5162155628204346,0.4614150524139404,0.431441068649292,0.4817569255828857,0.5064082145690918,0.4217076301574707,0.3509294986724854,0.3725242614746094,0.4058647155761719,0.3828179836273193,0.3302562236785889,0.2962672710418701,0.2725791931152344,0.2439296245574951,0.2283024787902832,0.2303886413574219,0.237809419631958,0.2389931678771973,0.223768949508667,0.2137279510498047,0.236361026763916,0.2574491500854492,0.1854956150054932,0.02544641494750977,-0.06826400756835938,-0.0144195556640625,0.06201982498168945,0.05117416381835938,0.02524852752685547,0.04000663757324219,0.0458681583404541,0.006692409515380859,-0.05255818367004395,-0.08986473083496094,-0.09476542472839355,-0.08765935897827148,-0.06859421730041504,-0.02869486808776855,0.0253748893737793,0.06352543830871582,0.08785128593444824,0.09472131729125977,0.04329442977905273,-0.01490116119384766,-0.01413583755493164,0.01172780990600586,0.01357555389404297,0.01187920570373535,0.03454327583312988,0.03420472145080566,-0.03983497619628906,-0.1340579986572266,-0.1721560955047607,-0.1535022258758545,-0.1235532760620117,-0.1102912425994873,-0.1255536079406738,-0.1519572734832764,-0.1594233512878418,-0.1555395126342773,-0.1757550239562988,-0.2247965335845947,-0.2560436725616455,-0.2162504196166992,-0.1258134841918945,-0.07954239845275879,-0.04295468330383301,0.05453944206237793,0.1096844673156738,0.04488706588745117,-0.05129694938659668,-0.1341009140014648,-0.2114081382751465,-0.2384376525878906,-0.1924741268157959,-0.1173543930053711,-0.05657315254211426,-0.00710606575012207,0.04443883895874023,0.09100675582885742,0.07316946983337402,-0.05235910415649414,-0.2188682556152344,-0.3382229804992676,-0.3889358043670654,-0.3952956199645996,-0.3707730770111084,-0.3087437152862549,-0.2365171909332275,-0.1878023147583008,-0.1242303848266602,-0.005350112915039062,0.09181737899780273,0.1063084602355957,0.09792447090148926,0.0773167610168457,0.007433891296386719,-0.05625128746032715,-0.08968830108642578,-0.1384174823760986,-0.1747846603393555,-0.1495146751403809,-0.1110208034515381,-0.1062929630279541,-0.1043975353240967,-0.09520649909973145,-0.09819746017456055,-0.0964665412902832,-0.0947105884552002,-0.09333491325378418,-0.06469845771789551,-0.01596212387084961,0.04252195358276367,0.09372830390930176,0.1070892810821533,0.08327126502990723,0.04422307014465332,0.01585841178894043,0.01943588256835938,0.04149079322814941,0.0466001033782959,0.05260229110717773,0.08810997009277344,0.102393627166748,0.05194544792175293,0.00518798828125,0.001496076583862305,-0.0112450122833252,-0.03898262977600098,-0.02821207046508789,0.03547072410583496,0.09462237358093262,0.1155233383178711,0.09084939956665039,0.05647540092468262,0.04810094833374023,0.04821896553039551,0.05562543869018555,0.07568597793579102,0.07732629776000977,0.05283594131469727,0.01743078231811523,-0.003970861434936523,0.01515030860900879,0.07562875747680664,0.1278328895568848,0.1448118686676025,0.1662766933441162,0.2200555801391602,0.2569198608398438,0.2450823783874512,0.2303576469421387,0.2174127101898193,0.1587605476379395,0.0561213493347168,-0.01396775245666504,-0.01873493194580078,-0.02825379371643066,-0.07720232009887695,-0.0887000560760498,-0.01914739608764648,0.0438082218170166,0.03504753112792969,-0.01571893692016602,-0.06505012512207031,-0.103384256362915,-0.1158130168914795,-0.05899786949157715,0.09589672088623047,0.2611303329467773,0.2845096588134766,0.1887071132659912,0.1232028007507324,0.09968876838684082,0.07791519165039062,0.1116836071014404,0.2097034454345703,0.2757024765014648,0.2912938594818115,0.3145468235015869,0.3234350681304932,0.2621793746948242,0.1776528358459473,0.1395511627197266,0.1227295398712158,0.09080052375793457,0.07138252258300781,0.1179933547973633,0.1911258697509766,0.193173885345459,0.1145410537719727,0.01239418983459473,-0.06419539451599121,-0.09338498115539551,-0.1061820983886719,-0.138477087020874,-0.1797091960906982,-0.2000796794891357,-0.2046108245849609,-0.2100634574890137,-0.2097725868225098,-0.1571035385131836,-0.0455164909362793,0.0553584098815918,0.08677959442138672,0.09087324142456055,0.1004219055175781,0.06679892539978027,-0.04311323165893555,-0.192030668258667,-0.3258085250854492,-0.4093611240386963,-0.4152703285217285,-0.3264737129211426,-0.2072298526763916,-0.1561605930328369,-0.1403498649597168,-0.06227612495422363,0.05787849426269531,0.1436686515808105,0.1960909366607666,0.2219951152801514,0.189741849899292,0.1221084594726562,0.1003432273864746,0.1663100719451904,0.2531850337982178,0.2551531791687012,0.2093362808227539,0.2228617668151855,0.2735233306884766,0.2746307849884033,0.2128028869628906,0.1089060306549072,0.03836989402770996,0.06689310073852539,0.1248979568481445,0.1115238666534424,0.06284952163696289,0.05339622497558594,0.0989377498626709,0.1601672172546387,0.1919424533843994,0.1905786991119385,0.1783013343811035,0.1659226417541504,0.1211798191070557,0.05180120468139648,0.01559138298034668,0.006508827209472656,0.003371238708496094,-0.01519918441772461,-0.08404016494750977,-0.1739776134490967,-0.2302718162536621,-0.2501416206359863,-0.2371180057525635,-0.1867222785949707,-0.1333487033843994,-0.1085197925567627,-0.0970757007598877,-0.07914304733276367,-0.05714774131774902,-0.05094647407531738,-0.08658289909362793,-0.1837170124053955,-0.3090012073516846,-0.3799712657928467,-0.3838372230529785,-0.3840041160583496,-0.4012715816497803,-0.4001617431640625,-0.3660070896148682,-0.3481340408325195,-0.3662228584289551,-0.3592967987060547,-0.2745282649993896,-0.1796352863311768,-0.1357352733612061,-0.08972048759460449,-0.003401041030883789,0.05288600921630859,0.05881667137145996,0.1000988483428955,0.1706254482269287,0.1759302616119385,0.09272456169128418,0.01512050628662109,-0.01965165138244629,-0.09928584098815918,-0.2381801605224609,-0.3428983688354492,-0.3776931762695312,-0.3712689876556396,-0.3261268138885498,-0.2228152751922607,-0.07860183715820312,0.01902341842651367,0.0383150577545166,0.05447864532470703,0.124129056930542,0.178675651550293,0.1518535614013672,0.09966135025024414,0.06166577339172363,0.01173734664916992,-0.05281805992126465,-0.09642481803894043,-0.128929615020752,-0.1387524604797363,-0.08528470993041992,0.009086132049560547,0.1215410232543945,0.2262699604034424,0.2736830711364746,0.2446520328521729,0.2059221267700195,0.2370524406433105,0.3258466720581055,0.354156494140625,0.2530372142791748,0.0867462158203125,-0.0546717643737793,-0.1072978973388672,-0.0771641731262207,-0.04005789756774902,-0.01622796058654785,0.01996517181396484,0.08200407028198242,0.1792716979980469,0.2931654453277588,0.369187593460083,0.3819417953491211,0.3265416622161865,0.2224230766296387,0.1204907894134521,0.05047082901000977,0.007990598678588867,-0.03097414970397949,-0.08239269256591797,-0.1122450828552246,-0.07627964019775391,-0.02334833145141602,-0.06317853927612305,-0.171438455581665,-0.2099061012268066,-0.1742351055145264,-0.1584279537200928,-0.1855146884918213,-0.2023303508758545,-0.18341064453125,-0.180736780166626,-0.2194356918334961,-0.2268850803375244,-0.1824092864990234,-0.1535654067993164,-0.128023624420166,-0.08289694786071777,-0.04343986511230469,-0.02217292785644531,-0.01724362373352051,-0.03773808479309082,-0.0829470157623291,-0.1348602771759033,-0.1884138584136963,-0.2104008197784424,-0.2191972732543945,-0.2367722988128662,-0.2223396301269531,-0.1626110076904297,-0.07941126823425293,0.03912806510925293,0.11566162109375,0.08272528648376465,0.03942489624023438,0.06415605545043945,0.1045870780944824,0.1060616970062256,0.0853419303894043,0.07935881614685059,0.06579756736755371,0.00153660774230957,-0.07517814636230469,-0.1192629337310791,-0.1507866382598877,-0.1957559585571289,-0.2645444869995117,-0.3556573390960693,-0.415414571762085,-0.4116916656494141,-0.3655552864074707,-0.2998900413513184,-0.2098190784454346,-0.1016151905059814,-0.05046725273132324,-0.06150126457214355,-0.0623619556427002,-0.04631161689758301,-0.05185961723327637,-0.07926225662231445,-0.0976717472076416,-0.07924079895019531,-0.07624149322509766,-0.1129651069641113,-0.1099550724029541,-0.04933595657348633,0.01945018768310547,0.07803082466125488,0.1130068302154541,0.1302754878997803,0.1562023162841797,0.196610689163208,0.2439332008361816,0.3291654586791992,0.4366064071655273,0.4645490646362305,0.418250560760498,0.3683304786682129,0.2905678749084473,0.1691997051239014,0.05361676216125488,-0.03695964813232422,-0.07847070693969727,-0.03806114196777344,0.08957147598266602,0.2337706089019775,0.3031373023986816,0.3433525562286377,0.4151725769042969,0.4412996768951416,0.37994384765625,0.3139281272888184,0.2728784084320068,0.2199065685272217,0.1586735248565674,0.1278269290924072,0.1168251037597656,0.1012861728668213,0.07497906684875488,0.05812406539916992,0.0922238826751709,0.1688659191131592,0.2292108535766602,0.2716147899627686,0.343165397644043,0.4173552989959717,0.4393231868743896,0.3985321521759033,0.3228187561035156,0.232994556427002,0.1174139976501465,-0.02826452255249023,-0.1357221603393555,-0.1378357410430908,-0.08910179138183594,-0.07886648178100586,-0.05733489990234375,0.04314184188842773,0.1597940921783447,0.1829075813293457,0.1290702819824219,0.110328197479248,0.1414084434509277,0.1740169525146484,0.2067792415618896,0.2781581878662109,0.3637802600860596,0.3925585746765137,0.3692722320556641,0.3537511825561523,0.3972625732421875,0.4671430587768555,0.4410111904144287,0.2930045127868652,0.1624786853790283,0.1068270206451416,0.01270651817321777,-0.1291561126708984,-0.2067792415618896,-0.1654672622680664,-0.08876562118530273,-0.08193612098693848,-0.08806467056274414,-0.05559206008911133,-0.07344603538513184,-0.1899230480194092,-0.2884328365325928,-0.29197096824646,-0.3025436401367188,-0.3687214851379395,-0.4070544242858887,-0.3647375106811523,-0.3185594081878662,-0.3318440914154053,-0.3730380535125732,-0.3945755958557129,-0.3989231586456299,-0.4151129722595215,-0.4024076461791992,-0.3154265880584717,-0.2292180061340332,-0.2070879936218262,-0.1865553855895996,-0.1489722728729248,-0.1558268070220947,-0.2020454406738281,-0.2272069454193115,-0.2311015129089355,-0.2570033073425293,-0.2973449230194092,-0.2860772609710693,-0.215831995010376,-0.1942646503448486,-0.2603483200073242,-0.3068041801452637,-0.3152048587799072,-0.3612947463989258,-0.3835713863372803,-0.330967903137207,-0.2797603607177734,-0.2672696113586426,-0.2559268474578857,-0.2416789531707764,-0.2227365970611572,-0.1664173603057861,-0.08775949478149414,-0.0364077091217041,-0.02409815788269043,-0.02141594886779785,-0.02130627632141113,-0.03302216529846191,-0.04803299903869629,-0.04748702049255371,-0.02660155296325684,0.002062320709228516,0.0248563289642334,0.01205801963806152,-0.02449274063110352,-0.01728177070617676,0.05877375602722168,0.1386308670043945,0.1394116878509521,0.06207466125488281,-0.02595305442810059,-0.08882522583007812,-0.1212358474731445,-0.1128208637237549,-0.09518623352050781,-0.06105780601501465,0.008512735366821289,0.08083105087280273,0.1211428642272949,0.1007258892059326,0.05165815353393555,0.01023650169372559,-0.04839658737182617,-0.1398921012878418,-0.2081942558288574,-0.1956367492675781,-0.1454329490661621,-0.1555466651916504,-0.234757661819458,-0.2857434749603271,-0.2455329895019531,-0.1675772666931152,-0.1357507705688477,-0.1487851142883301,-0.1131975650787354,-0.01751542091369629,0.08159518241882324,0.1712667942047119,0.282738208770752,0.3802490234375,0.3490233421325684,0.2188503742218018,0.1087653636932373,0.02956509590148926,-0.04940986633300781,-0.07881760597229004,-0.03862977027893066,-0.0006663799285888672,-0.0308680534362793,-0.09192228317260742,-0.09577274322509766,-0.06350278854370117,-0.05372762680053711,-0.02846240997314453,0.0462651252746582,0.1036703586578369,0.1423144340515137,0.2371573448181152,0.3225934505462646,0.2877342700958252,0.2004909515380859,0.1530158519744873,0.1412725448608398,0.1503658294677734,0.1854407787322998,0.2048075199127197,0.1674473285675049,0.1384472846984863,0.153043270111084,0.1158535480499268,0.00559687614440918,-0.03789067268371582,0.005627870559692383,-0.0009500980377197266,-0.04865646362304688,-0.02045989036560059,0.007710456848144531,-0.06425976753234863,-0.1265227794647217,-0.1130867004394531,-0.1453745365142822,-0.2181541919708252,-0.2016007900238037,-0.12992262840271,-0.1224267482757568,-0.1291608810424805,-0.04499197006225586,0.05387306213378906,0.08767604827880859,0.1326382160186768,0.2067947387695312,0.2410399913787842,0.2371370792388916,0.255049467086792,0.2711272239685059,0.2464151382446289,0.192410945892334,0.1127922534942627,0.03291010856628418,-0.02382636070251465,-0.04825830459594727,-0.04639387130737305,-0.01710653305053711,0.06331086158752441,0.1772332191467285,0.2413153648376465,0.2208912372589111,0.1574110984802246,0.07940530776977539,0.01265645027160645,-0.05449891090393066,-0.107954740524292,-0.09431838989257812,-0.02211213111877441,0.03520369529724121,0.03648638725280762,0.02647995948791504,-0.002558231353759766,-0.07210612297058105,-0.1013314723968506,-0.05117058753967285,-0.01290678977966309,0.01728177070617676,0.09264945983886719,0.1249110698699951,0.06801605224609375,0.001393556594848633,-0.0407099723815918,-0.0671696662902832,-0.07417917251586914,-0.05435705184936523,0.009636878967285156,0.08194446563720703,0.1103043556213379,0.133814811706543,0.1891827583312988,0.2122890949249268,0.1305186748504639,-0.003087520599365234,-0.06759166717529297,-0.03867268562316895,0.02712368965148926,0.06148457527160645,0.04294514656066895,0.004612207412719727,0.009605884552001953,0.05472660064697266,0.06911873817443848,0.06597518920898438,0.07414817810058594,0.0528252124786377,-0.005735158920288086,-0.06006240844726562,-0.1366782188415527,-0.2773571014404297,-0.3881967067718506,-0.3621792793273926,-0.2760684490203857,-0.237964391708374,-0.2129590511322021,-0.1263153553009033,-0.02991080284118652,-0.03762960433959961,-0.09441375732421875,-0.06066799163818359,0.03503799438476562,0.05707025527954102,0.03266572952270508,0.01555919647216797,-0.05159735679626465,-0.1263630390167236,-0.1443016529083252,-0.1383531093597412,-0.1219749450683594,-0.06717920303344727,0.01101374626159668,0.04819035530090332,0.0424349308013916,0.01542448997497559,0.01614689826965332,0.1033031940460205,0.2149415016174316,0.2528548240661621,0.2363312244415283,0.2567636966705322,0.3435301780700684,0.3917789459228516,0.3656899929046631,0.3786802291870117,0.4155528545379639,0.391463041305542,0.3781616687774658,0.4242086410522461,0.4517090320587158,0.4443597793579102,0.4131793975830078,0.3662681579589844,0.3400754928588867,0.3126060962677002,0.279616117477417,0.2682220935821533,0.2510190010070801,0.2067804336547852,0.180286169052124,0.192488431930542,0.1763069629669189,0.0968635082244873,0.01789212226867676,-0.04415750503540039,-0.1171636581420898,-0.1729822158813477,-0.1799607276916504,-0.1435589790344238,-0.1194965839385986,-0.1202273368835449,-0.08916020393371582,-0.03489971160888672,-0.02483606338500977,-0.04991054534912109,-0.06107926368713379,-0.04248142242431641,-0.02831697463989258,-0.04415512084960938,-0.05213141441345215,-0.04206299781799316,-0.01833677291870117,0.007168054580688477,0.005693435668945312,-0.01940727233886719,-0.05690097808837891,-0.1093637943267822,-0.1539468765258789,-0.1517617702484131,-0.1344585418701172,-0.1578724384307861,-0.2158260345458984,-0.2387726306915283,-0.2080392837524414,-0.1940369606018066,-0.1952874660491943,-0.1720702648162842,-0.1748490333557129,-0.2414512634277344,-0.2966320514678955,-0.2992522716522217,-0.2784633636474609,-0.2434349060058594,-0.2265071868896484,-0.255131721496582,-0.2924931049346924,-0.3040742874145508,-0.3277039527893066,-0.3858280181884766,-0.4109275341033936,-0.3529047966003418,-0.2926838397979736,-0.2795577049255371,-0.2288830280303955,-0.1322793960571289,-0.1128137111663818,-0.1968801021575928,-0.2600979804992676,-0.235062837600708,-0.1895380020141602,-0.1758956909179688,-0.1469540596008301,-0.08721470832824707,-0.08948683738708496,-0.1619100570678711,-0.242849588394165,-0.3147351741790771,-0.3772962093353271,-0.4253220558166504,-0.4050946235656738,-0.3314101696014404,-0.2613914012908936,-0.1479208469390869,0.01937389373779297,0.0970757007598877,0.0228583812713623,-0.05158305168151855,-0.02488374710083008,-0.007328987121582031,-0.06154298782348633,-0.07293343544006348,0.03669977188110352,0.1307773590087891,0.0926506519317627,0.03688454627990723,0.0398099422454834,0.06070971488952637,0.1028668880462646,0.1313042640686035,0.06441354751586914,-0.04225969314575195,-0.07749199867248535,-0.05406022071838379,-0.004792213439941406,0.08029818534851074,0.1482665538787842,0.1338779926300049,0.09474396705627441,0.09771466255187988,0.08188128471374512,-0.02439498901367188,-0.1367080211639404,-0.1573801040649414,-0.1006412506103516,0.001883506774902344,0.1173925399780273,0.1942217350006104,0.2182745933532715,0.1927828788757324,0.1188015937805176,0.05416631698608398,0.0155484676361084,-0.01411080360412598,-0.04817962646484375,-0.08796453475952148,-0.06186962127685547,0.06875157356262207,0.1971542835235596,0.2579367160797119,0.3132688999176025,0.3778302669525146,0.3677570819854736,0.2937400341033936,0.2469837665557861,0.2377259731292725,0.1972353458404541,0.1512992382049561,0.1402914524078369,0.1625931262969971,0.2100706100463867,0.2302432060241699,0.2624869346618652,0.3459513187408447,0.3935015201568604,0.3636729717254639,0.3308951854705811,0.2909600734710693,0.2101767063140869,0.1684463024139404,0.2097630500793457,0.2448010444641113,0.2212488651275635,0.1956653594970703,0.1946115493774414,0.1189661026000977,-0.05255579948425293,-0.1737451553344727,-0.1694011688232422,-0.1168179512023926,-0.09695172309875488,-0.07467150688171387,-0.04065275192260742,-0.04263401031494141,-0.06560683250427246,-0.07405281066894531,-0.06515026092529297,-0.05221724510192871,-0.04699826240539551,-0.02222299575805664,0.03751277923583984,0.1060259342193604,0.1419258117675781,0.118553638458252,0.01291513442993164,-0.1377904415130615,-0.2518415451049805,-0.3521597385406494,-0.4294490814208984,-0.4093146324157715,-0.3026950359344482,-0.1891851425170898,-0.1037156581878662,-0.03468632698059082,0.007233619689941406,0.01357793807983398,-0.03990054130554199,-0.1447689533233643,-0.2008533477783203,-0.1564419269561768,-0.08028626441955566,-0.01796483993530273,0.01292824745178223,0.008420944213867188,0.02897739410400391,0.07495522499084473,0.1025390625,0.1377999782562256,0.1981532573699951,0.2324557304382324,0.2097082138061523,0.1877224445343018,0.1943421363830566,0.1601636409759521,0.05930781364440918,-0.03632187843322754,-0.07218360900878906,-0.060272216796875,-0.008338689804077148,0.06290197372436523,0.1142632961273193,0.1195847988128662,0.1130008697509766,0.1479089260101318,0.1629757881164551,0.1109564304351807,0.05691647529602051,0.04769086837768555,0.07097721099853516,0.1316046714782715,0.1888024806976318,0.1877450942993164,0.1726198196411133,0.2002513408660889,0.1993012428283691,0.1526176929473877,0.1453375816345215,0.1908266544342041,0.2185630798339844,0.1396644115447998,0.01501917839050293,-0.01013040542602539,0.03006458282470703,-0.001025199890136719,-0.06693601608276367,-0.064544677734375,-0.01788496971130371,0.01611709594726562,0.02867698669433594,0.02471685409545898,-0.02246260643005371,-0.1102495193481445,-0.1537823677062988,-0.1244747638702393,-0.1241981983184814,-0.1969468593597412,-0.2564692497253418,-0.2687203884124756,-0.2442634105682373,-0.1675403118133545,-0.08306264877319336,-0.06123781204223633,-0.08676767349243164,-0.115891695022583,-0.1229000091552734,-0.1211190223693848,-0.1363658905029297,-0.1709830760955811,-0.1945602893829346,-0.1642692089080811,-0.125889778137207,-0.159226655960083,-0.2146530151367188,-0.2043187618255615,-0.2042984962463379,-0.2947759628295898,-0.3925490379333496,-0.4083371162414551,-0.3898966312408447,-0.3970813751220703,-0.3851997852325439,-0.3321242332458496,-0.2535533905029297,-0.1806557178497314,-0.1550662517547607,-0.1681900024414062,-0.1446449756622314,-0.05892038345336914,0.02174258232116699,0.02561688423156738,-0.04270434379577637,-0.1385819911956787,-0.2266478538513184,-0.2720439434051514,-0.2835237979888916,-0.2843797206878662,-0.2294826507568359,-0.0704801082611084,0.1061379909515381,0.2044880390167236,0.2394270896911621,0.2226388454437256,0.1543259620666504,0.06138443946838379,0.0171959400177002,0.04782795906066895,0.09116530418395996,0.1672101020812988,0.281519889831543,0.3277921676635742,0.2963769435882568,0.2607190608978271,0.2120733261108398,0.1388216018676758,0.1000869274139404,0.116347074508667,0.1391732692718506,0.124518871307373,0.08089303970336914,0.04308462142944336,0.02354621887207031,0.01572608947753906,-0.05265116691589355,-0.1433861255645752,-0.1416707038879395,-0.0937199592590332,-0.06509780883789062,-0.03739356994628906,0.002115964889526367,0.06749749183654785,0.127418041229248,0.1121783256530762,0.07097840309143066,0.1605796813964844,0.4047918319702148,0.599292516708374,0.6099939346313477,0.5608046054840088,0.5650365352630615,0.5230474472045898,0.3532683849334717,0.1963531970977783,0.1306366920471191,0.05523443222045898,-0.01800417900085449,0.0314795970916748,0.1560080051422119,0.2192568778991699,0.2765011787414551,0.4293406009674072,0.5187594890594482,0.437471866607666,0.3794336318969727,0.4129683971405029,0.3684961795806885,0.2611827850341797,0.2086210250854492,0.169903039932251,0.1301157474517822,0.118488073348999,0.1456534862518311,0.1463854312896729,0.08290529251098633,0.04340410232543945,0.08311629295349121,0.07716655731201172,-0.02609848976135254,-0.06231904029846191,-0.02110481262207031,-0.07715344429016113,-0.2134931087493896,-0.2763175964355469,-0.2558839321136475,-0.2260673046112061,-0.1882338523864746,-0.1330173015594482,-0.1215958595275879,-0.1863408088684082,-0.2734482288360596,-0.3172099590301514,-0.3093171119689941,-0.2313041687011719,-0.1151895523071289,-0.04395008087158203,-0.01453399658203125,0.01770615577697754,0.01782774925231934,-0.02254247665405273,-0.05280137062072754,-0.06240963935852051,-0.0675511360168457,-0.06893634796142578,-0.04823565483093262,-0.01139998435974121,0.008262395858764648,-0.009744167327880859,-0.07728934288024902,-0.193779468536377,-0.2735233306884766,-0.2891862392425537,-0.3109931945800781,-0.311819314956665,-0.2305054664611816,-0.2005958557128906,-0.2673137187957764,-0.2798748016357422,-0.2033495903015137,-0.1278364658355713,-0.08462786674499512,-0.05217313766479492,-0.04861116409301758,-0.07060408592224121,-0.06536364555358887,-0.05518436431884766,-0.09241580963134766,-0.1476740837097168,-0.1820826530456543,-0.2246356010437012,-0.2747786045074463,-0.2759444713592529,-0.2667152881622314,-0.2783405780792236,-0.241774320602417,-0.1455020904541016,-0.05825519561767578,-0.02072691917419434,-0.01238822937011719,-0.02627849578857422,-0.04900217056274414,-0.08242964744567871,-0.1587402820587158,-0.22247314453125,-0.2385425567626953,-0.2289271354675293,-0.1779448986053467,-0.09516716003417969,-0.02348899841308594,-0.004941225051879883,-0.05681633949279785,-0.1151382923126221,-0.08947372436523438,-0.02215981483459473,-0.01302838325500488,-0.03697514533996582,-0.00983119010925293,0.08438229560852051,0.1777756214141846,0.2284121513366699,0.249640941619873,0.1911020278930664,0.03107666969299316,-0.1262795925140381,-0.1523995399475098,-0.1009571552276611,-0.1164555549621582,-0.144195556640625,-0.1143062114715576,-0.1360845565795898,-0.2056598663330078,-0.1910710334777832,-0.1336276531219482,-0.1287734508514404,-0.1489782333374023,-0.165398120880127,-0.1790201663970947,-0.2011775970458984,-0.2415525913238525,-0.2742063999176025,-0.2384567260742188,-0.1389265060424805,-0.07177352905273438,-0.08158445358276367,-0.1113522052764893,-0.1043975353240967,-0.06020545959472656,0.005143880844116211,0.05522251129150391,0.1404654979705811,0.2861511707305908,0.3770172595977783,0.4038608074188232,0.4246830940246582,0.3609848022460938,0.2348792552947998,0.1697134971618652,0.1820993423461914,0.1828944683074951,0.1445460319519043,0.1272928714752197,0.07399320602416992,-0.02221345901489258,-0.07982254028320312,-0.08445620536804199,-0.0426328182220459,-0.01595258712768555,-0.01194119453430176,0.01526355743408203,0.04627466201782227,0.06043076515197754,0.08861064910888672,0.1514017581939697,0.2107274532318115,0.2689969539642334,0.343935489654541,0.362706184387207,0.2861082553863525,0.1547574996948242,0.03673195838928223,0.01904487609863281,0.07148981094360352,0.1137340068817139,0.1363837718963623,0.151221752166748,0.1133072376251221,0.01210212707519531,-0.05710959434509277,-0.07044196128845215,-0.0843048095703125,-0.07283449172973633,-0.02923369407653809,0.01837611198425293,0.1272499561309814,0.294187068939209,0.3470051288604736,0.2109074592590332,0.04992246627807617,-0.0306093692779541,-0.04784107208251953,-0.04009008407592773,-0.03405213356018066,0.01448512077331543,0.06487131118774414,0.02448320388793945,-0.05434274673461914,-0.09010791778564453,-0.1071774959564209,-0.1696872711181641,-0.2587580680847168,-0.3148794174194336,-0.3311431407928467,-0.3129982948303223,-0.3005790710449219,-0.2893197536468506,-0.2398848533630371,-0.2367711067199707,-0.288165807723999,-0.2677822113037109,-0.1815652847290039,-0.1358640193939209,-0.1017570495605469,-0.03460884094238281,0.02584576606750488,0.0674891471862793,0.07767558097839355,0.02062320709228516,-0.06860852241516113,-0.1059365272521973,-0.1166260242462158,-0.1583433151245117,-0.2108883857727051,-0.2360153198242188,-0.2022469043731689,-0.1453030109405518,-0.1469063758850098,-0.1877117156982422,-0.2233004570007324,-0.2635455131530762,-0.3026485443115234,-0.3106772899627686,-0.2597498893737793,-0.1773452758789062,-0.1241350173950195,-0.07615447044372559,0.06979227066040039,0.2825570106506348,0.3961491584777832,0.3707301616668701,0.26772141456604,0.1673626899719238,0.0917816162109375,0.02960801124572754,-0.02711176872253418,-0.1075553894042969,-0.1975536346435547,-0.2160191535949707,-0.2084434032440186,-0.2194643020629883,-0.162656307220459,-0.01125574111938477,0.1115036010742188,0.1050996780395508,0.05298972129821777,0.01964926719665527,-0.01906991004943848,-0.02443075180053711,-0.03110051155090332,-0.07970809936523438,-0.1030373573303223,-0.0872337818145752,-0.02931594848632812,0.04899263381958008,0.110398530960083,0.1438367366790771,0.1747786998748779,0.2827346324920654,0.423271656036377,0.5028676986694336,0.5244994163513184,0.5521059036254883,0.6285905838012695,0.622408390045166,0.4679787158966064,0.3345823287963867,0.3237974643707275,0.3302121162414551,0.2759242057800293,0.2187168598175049,0.1525521278381348,0.1085925102233887,0.1166200637817383,0.06543874740600586,-0.0653529167175293,-0.1516973972320557,-0.1328778266906738,-0.0825047492980957,-0.02608537673950195,0.0612485408782959,0.1366841793060303,0.201256275177002,0.206829309463501,0.1452445983886719,0.1184570789337158,0.05608439445495605,-0.09045124053955078,-0.1708006858825684,-0.06216287612915039,0.1917111873626709,0.3799188137054443,0.4125034809112549,0.3953516483306885,0.3753423690795898,0.2919816970825195,0.1376891136169434,0.02138495445251465,-0.03174662590026855,-0.06757736206054688,-0.09517073631286621,-0.07043004035949707,-0.03513097763061523,-0.1057827472686768,-0.2258956432342529,-0.2914190292358398,-0.324476957321167,-0.3465938568115234,-0.3470242023468018,-0.2948391437530518,-0.188065767288208,-0.1614296436309814,-0.2357244491577148,-0.2296948432922363,-0.1537179946899414,-0.1899814605712891,-0.3291630744934082,-0.4703962802886963,-0.5514287948608398,-0.5376720428466797,-0.4850661754608154,-0.4479515552520752,-0.385286808013916,-0.2978909015655518,-0.2907490730285645,-0.3608548641204834,-0.3923773765563965,-0.3515195846557617,-0.311734676361084,-0.3281867504119873,-0.3638434410095215,-0.3795969486236572,-0.4272592067718506,-0.4706990718841553,-0.4349219799041748,-0.3419220447540283,-0.2096271514892578,-0.08709430694580078,-0.03331422805786133,-0.04600763320922852,-0.06988763809204102,-0.08574008941650391,-0.1145064830780029,-0.1406455039978027,-0.1361632347106934,-0.1328563690185547,-0.1508963108062744,-0.1270592212677002,-0.06492972373962402,-0.06862878799438477,-0.1283526420593262,-0.1447188854217529,-0.1315402984619141,-0.1403522491455078,-0.1747715473175049,-0.2001583576202393,-0.1627147197723389,-0.07454872131347656,-0.01477718353271484,0.009555816650390625,0.001329183578491211,-0.07404446601867676,-0.1276087760925293,-0.08341193199157715,-0.06098389625549316,-0.08683323860168457,-0.06570816040039062,-0.02084612846374512,-0.0113987922668457,0.002988576889038086,-0.007156133651733398,-0.1021111011505127,-0.2213442325592041,-0.2578604221343994,-0.1996159553527832,-0.1739645004272461,-0.1933562755584717,-0.1426935195922852,-0.003820657730102539,0.06719827651977539,0.05083799362182617,0.07003426551818848,0.0977170467376709,0.08935809135437012,0.0795900821685791,0.1104128360748291,0.2006316184997559,0.3012967109680176,0.3950190544128418,0.5004262924194336,0.5753886699676514,0.5720531940460205,0.5739116668701172,0.6295287609100342,0.5924296379089355,0.460503101348877,0.4181277751922607,0.4883253574371338,0.4964828491210938,0.3767919540405273,0.2859377861022949,0.2799463272094727,0.2606058120727539,0.256727933883667,0.32401442527771,0.3671014308929443,0.3477907180786133,0.3544557094573975,0.3927457332611084,0.3562939167022705,0.23468017578125,0.1195454597473145,0.01325845718383789,-0.1195108890533447,-0.2210628986358643,-0.2141654491424561,-0.09296417236328125,0.06734609603881836,0.1879119873046875,0.276947021484375,0.3428113460540771,0.2875912189483643,0.1304137706756592,0.06228208541870117,0.1328861713409424,0.1579439640045166,0.0674593448638916,0.05530714988708496,0.1198482513427734,0.08605599403381348,-0.0001811981201171875,-0.08151769638061523,-0.1606059074401855,-0.1831293106079102,-0.198216438293457,-0.2239811420440674,-0.2116155624389648,-0.2083122730255127,-0.2158045768737793,-0.174705982208252,-0.1593375205993652,-0.1934278011322021,-0.1913022994995117,-0.1743435859680176,-0.206301212310791,-0.2425980567932129,-0.2272140979766846,-0.1420176029205322,-0.01579761505126953,0.05242705345153809,0.05344152450561523,0.09473443031311035,0.1971745491027832,0.2610409259796143,0.2892804145812988,0.2902507781982422,0.2542972564697266,0.2170932292938232,0.1204848289489746,-0.0170433521270752,-0.1248371601104736,-0.2254676818847656,-0.3113245964050293,-0.3349542617797852,-0.279916524887085,-0.212104320526123,-0.2028501033782959,-0.211029052734375,-0.1831376552581787,-0.1331162452697754,-0.1027417182922363,-0.08855104446411133,-0.06888389587402344,-0.08046269416809082,-0.07936477661132812,-0.01208066940307617,0.07656335830688477,0.1446449756622314,0.1453506946563721,0.1276242733001709,0.1837313175201416,0.2321851253509521,0.160142183303833,0.1076984405517578,0.2417922019958496,0.4063975811004639,0.4001331329345703,0.3143680095672607,0.2455747127532959,0.1397848129272461,0.004602670669555664,-0.1138472557067871,-0.1551127433776855,-0.07321834564208984,-0.0005280971527099609,-0.05382180213928223,-0.1284956932067871,-0.1547729969024658,-0.1855182647705078,-0.2150940895080566,-0.2193105220794678,-0.2024507522583008,-0.1635491847991943,-0.1080119609832764,-0.05222320556640625,0.04106044769287109,0.1784944534301758,0.2218794822692871,0.1591193675994873,0.06786823272705078,-0.07369875907897949,-0.2137410640716553,-0.3058421611785889,-0.3084361553192139,-0.21297454]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>AR15</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"thresh"</value></param>
<param><key>size</key><value>1024*10</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.0</value></param>
<param><key>tr_level</key><value>.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"filter out"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>100.0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"direct audio"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
