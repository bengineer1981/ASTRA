<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xcorr_tester</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_mic_offset</value></param>
<param><key>value</key><value>1024*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d1</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d2</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d3</value></param>
<param><key>value</key><value>-64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mic_distance</value></param>
<param><key>value</key><value>.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>astra_xcorr_ts_ff</key>
<param><key>id</key><value>astra_xcorr_ts_ff_0</value></param>
<param><key>ip_address</key><value>127.0.0.1</value></param>
<param><key>center_mic_offset</key><value>center_mic_offset</value></param>
<param><key>mic_distance</key><value>mic_distance</value></param>
<param><key>node_number</key><value>1</value></param>
<param><key>port_num</key><value>5556</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_window</key><value>15000</value></param>
<param><key>test_number</key><value>AR.50m.60deg.shot3</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>plughw:2,0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>d2+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>d3+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>delay</key><value>d1+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ben/Desktop/senior_design/field_test/audio_recordings/ar15</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>180</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>180</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1.179933547973633,1.15540623664856,1.155078411102295,1.163452863693237,1.239925622940063,1.36101245880127,1.407444477081299,1.350671052932739,1.32402777671814,1.379489898681641,1.445531845092773,1.507818698883057,1.494377851486206,1.430034637451172,1.431822776794434,1.481473445892334,1.535385847091675,1.570522785186768,1.510113477706909,1.38479471206665,1.298338174819946,1.259267330169678,1.152783632278442,0.9357631206512451,0.7036924362182617,0.4887580871582031,0.3458559513092041,0.2987384796142578,0.2796947956085205,0.2750754356384277,0.3061294555664062,0.363081693649292,0.3769397735595703,0.3798305988311768,0.4043281078338623,0.3748238086700439,0.3038942813873291,0.219196081161499,0.1848042011260986,0.1999139785766602,0.2507865428924561,0.3082454204559326,0.3347396850585938,0.3519952297210693,0.3687441349029541,0.2770423889160156,0.1018643379211426,0.006705522537231445,0.04351139068603516,0.1997947692871094,0.325620174407959,0.3236234188079834,0.3346800804138184,0.3716945648193359,0.3718733787536621,0.3768503665924072,0.388413667678833,0.3367364406585693,0.2978146076202393,0.2866089344024658,0.3172755241394043,0.4214048385620117,0.6233155727386475,0.7140636444091797,0.6553828716278076,0.5649924278259277,0.5250275135040283,0.4478693008422852,0.3611445426940918,0.3557801246643066,0.3936588764190674,0.4042387008666992,0.3824830055236816,0.4211962223052979,0.5597472190856934,0.7307231426239014,0.7966458797454834,0.7790327072143555,0.7361173629760742,0.6895959377288818,0.6504952907562256,0.660240650177002,0.7661581039428711,0.9269416332244873,1.057088375091553,1.071542501449585,1.032501459121704,1.007795333862305,1.070141792297363,1.123249530792236,1.120477914810181,1.090019941329956,1.137256622314453,1.175910234451294,1.119405031204224,0.9328126907348633,0.7007122039794922,0.5707740783691406,0.5196630954742432,0.4939138889312744,0.3800690174102783,0.2682507038116455,0.2144575119018555,0.1825094223022461,0.1346170902252197,0.04729628562927246,-0.05891919136047363,-0.1192986965179443,-0.1697838306427002,-0.2210140228271484,-0.222623348236084,-0.2506077289581299,-0.3661215305328369,-0.4357397556304932,-0.4700124263763428,-0.4557371139526367,-0.4233121871948242,-0.3793239593505859,-0.2820193767547607,-0.2376139163970947,-0.3368556499481201,-0.5677640438079834,-0.8019208908081055,-0.9412169456481934,-1.035839319229126,-1.157462596893311,-1.231074333190918,-1.207560300827026,-1.112997531890869,-0.9863078594207764,-0.8715689182281494,-0.7534325122833252,-0.638812780380249,-0.5480647087097168,-0.4346966743469238,-0.316321849822998,-0.1849234104156494,-0.07876753807067871,-0.0921785831451416,-0.09647011756896973,0.005781650543212891,0.1439750194549561,0.2824366092681885,0.3425776958465576,0.2823472023010254,0.2355575561523438,0.2604126930236816,0.2892911434173584,0.2869665622711182,0.2122223377227783,0.09751319885253906,0.06070733070373535,0.1039803028106689,0.1340210437774658,0.1369118690490723,0.1399219036102295,0.1253783702850342,0.06300210952758789,-0.007838010787963867,-0.01382827758789062,0.01290440559387207,-0.01454353332519531,-0.116884708404541,-0.2138614654541016,-0.3097653388977051,-0.439375638961792,-0.5881786346435547,-0.6817877292633057,-0.7315278053283691,-0.8122920989990234,-0.9610950946807861,-1.05014443397522,-1.093089580535889,-1.103699207305908,-1.113414764404297,-1.115202903747559,-1.091927289962769,-1.056075096130371,-1.051604747772217,-1.073002815246582,-1.088976860046387,-1.076698303222656,-0.9653568267822266,-0.803530216217041,-0.6985366344451904,-0.628054141998291,-0.6299316883087158,-0.6602108478546143,-0.6623566150665283,-0.6177723407745361,-0.55733323097229,-0.4845559597015381,-0.4507899284362793,-0.4942417144775391,-0.553429126739502,-0.6479024887084961,-0.7550716400146484,-0.881195068359375,-0.9694099426269531,-0.95367431640625,-0.9045898914337158,-0.870048999786377,-0.7990002632141113,-0.7402300834655762,-0.7515847682952881,-0.8203089237213135,-0.9233951568603516,-0.9199976921081543,-0.8470416069030762,-0.8143186569213867,-0.8596181869506836,-0.888526439666748,-0.915825366973877,-0.9152889251708984,-0.9392499923706055,-1.025408506393433,-1.1025071144104,-1.070737838745117,-0.9591579437255859,-0.9142458438873291,-0.8504688739776611,-0.7839202880859375,-0.7117688655853271,-0.6461143493652344,-0.6539523601531982,-0.7367730140686035,-0.799328088760376,-0.7898509502410889,-0.7338225841522217,-0.6334483623504639,-0.5997717380523682,-0.7055103778839111,-0.7853507995605469,-0.8056461811065674,-0.7474720478057861,-0.6923079490661621,-0.6375312805175781,-0.6628036499023438,-0.6712079048156738,-0.6377696990966797,-0.5894601345062256,-0.6132423877716064,-0.7299184799194336,-0.820845365524292,-0.7703900337219238,-0.632166862487793,-0.5221068859100342,-0.4909634590148926,-0.5370378494262695,-0.6240010261535645,-0.7435977458953857,-0.8384287357330322,-0.9499192237854004,-1.089036464691162,-1.20091438293457,-1.220792531967163,-1.17957592010498,-1.010209321975708,-0.7560551166534424,-0.5563497543334961,-0.5407929420471191,-0.6246268749237061,-0.7064938545227051,-0.7908940315246582,-0.8730590343475342,-0.8932352066040039,-0.8508265018463135,-0.8125901222229004,-0.7454752922058105,-0.7089674472808838,-0.7221400737762451,-0.7258355617523193,-0.6654560565948486,-0.5536377429962158,-0.3630220890045166,-0.149071216583252,-0.005453824996948242,0.01439452171325684,-0.1017153263092041,-0.2577304840087891,-0.3643929958343506,-0.4370212554931641,-0.4135370254516602,-0.3212988376617432,-0.1671910285949707,-0.03159046173095703,0.009238719940185547,-0.04884600639343262,-0.2017319202423096,-0.3861486911773682,-0.4726946353912354,-0.469207763671875,-0.421375036239624,-0.394284725189209,-0.4011094570159912,-0.3896653652191162,-0.3541409969329834,-0.336378812789917,-0.2613365650177002,-0.1191198825836182,-0.0852048397064209,-0.1505613327026367,-0.2729594707489014,-0.4051625728607178,-0.425189733505249,-0.3170967102050781,-0.2623498439788818,-0.2737939357757568,-0.3663599491119385,-0.4277825355529785,-0.4166066646575928,-0.3830194473266602,-0.3363490104675293,-0.3044009208679199,-0.3609657287597656,-0.4033744335174561,-0.3277957439422607,-0.210881233215332,-0.1432895660400391,-0.09021162986755371,-0.02840161323547363,-0.006645917892456055,-0.03445148468017578,-0.08508563041687012,-0.1582503318786621,-0.2447366714477539,-0.3395974636077881,-0.4654824733734131,-0.5554854869842529,-0.5859136581420898,-0.5135536193847656,-0.4076957702636719,-0.3496110439300537,-0.3333687782287598,-0.2620816230773926,-0.1266896724700928,-0.02765655517578125,-0.02011656761169434,-0.09363889694213867,-0.2109408378601074,-0.2575516700744629,-0.2086758613586426,-0.09647011756896973,-0.01233816146850586,0.001579523086547852,-0.04231929779052734,-0.05590915679931641,-0.05754828453063965,-0.02694129943847656,0.09462237358093262,0.2267658710479736,0.3123879432678223,0.3509223461151123,0.3547370433807373,0.4331469535827637,0.6286799907684326,0.8166134357452393,0.9214878082275391,0.9341239929199219,0.8971095085144043,0.8801817893981934,0.9218156337738037,1.02919340133667,1.14867091178894,1.168966293334961,1.039057970046997,0.796973705291748,0.6118416786193848,0.6293952465057373,0.7477402687072754,0.766068696975708,0.6854534149169922,0.5964338779449463,0.5068778991699219,0.417858362197876,0.3920197486877441,0.3895759582519531,0.4433989524841309,0.4883408546447754,0.4658102989196777,0.3862082958221436,0.2789795398712158,0.1404881477355957,-0.003337860107421875,-0.1200735569000244,-0.2142786979675293,-0.247269868850708,-0.2519488334655762,-0.2308785915374756,-0.1363158226013184,0.002324581146240234,0.1113414764404297,0.1375079154968262,0.170588493347168,0.2432763576507568,0.2958476543426514,0.3120303153991699,0.3469884395599365,0.3813505172729492,0.4195570945739746,0.414431095123291,0.3077685832977295,0.2437233924865723,0.3292858600616455,0.451505184173584,0.5004405975341797,0.4833340644836426,0.5098879337310791,0.60996413230896,0.6918609142303467,0.662684440612793,0.5413293838500977,0.4307925701141357,0.4237592220306396,0.4457235336303711,0.4062056541442871,0.2827942371368408,0.1873970031738281,0.1367926597595215,0.05790591239929199,0.01621246337890625,0.04875659942626953,0.07590651512145996,0.07972121238708496,0.08556246757507324,0.06556510925292969,0.05897879600524902,0.07709860801696777,0.07444620132446289,0.09554624557495117,0.2099573612213135,0.3254711627960205,0.3168284893035889,0.1929700374603271,0.0191032886505127,-0.08252263069152832,-0.1451671123504639,-0.1759827136993408,-0.2365410327911377,-0.2114176750183105,-0.002443790435791016,0.2582967281341553,0.4665553569793701,0.5894303321838379,0.6208419799804688,0.6394386291503906,0.6955265998840332,0.7688701152801514,0.7860660552978516,0.6240606307983398,0.338435173034668,0.1753568649291992,0.1701414585113525,0.2554357051849365,0.3706514835357666,0.3947913646697998,0.405043363571167,0.4326999187469482,0.4370808601379395,0.366896390914917,0.247269868850708,0.1418590545654297,0.02974271774291992,-0.06631016731262207,-0.03385543823242188,0.06601214408874512,0.07998943328857422,-0.02110004425048828,-0.08803606033325195,-0.05379319190979004,0.08240342140197754,0.2104341983795166,0.2464950084686279,0.1583397388458252,0.008016824722290039,-0.1240670680999756,-0.3432929515838623,-0.6355345249176025,-0.806659460067749,-0.756382942199707,-0.655055046081543,-0.5742013454437256,-0.5470514297485352,-0.5723237991333008,-0.5808472633361816,-0.5026161670684814,-0.3685355186462402,-0.2427101135253906,-0.169217586517334,-0.1928806304931641,-0.3704726696014404,-0.5763471126556396,-0.6600916385650635,-0.5838274955749512,-0.4257857799530029,-0.3294646739959717,-0.3584027290344238,-0.470966100692749,-0.4824399948120117,-0.4775822162628174,-0.5736649036407471,-0.6148815155029297,-0.5832314491271973,-0.5802512168884277,-0.6519556045532227,-0.6901919841766357,-0.5959868431091309,-0.4233419895172119,-0.282973051071167,-0.1544952392578125,-0.1412928104400635,-0.2216100692749023,-0.2842545509338379,-0.3125369548797607,-0.3484487533569336,-0.3347694873809814,-0.3279745578765869,-0.2937614917755127,-0.1771450042724609,-0.05376338958740234,0.06440281867980957,0.2169609069824219,0.2545416355133057,0.1965463161468506,0.09545683860778809,-0.02714991569519043,-0.0400841236114502,-0.1189708709716797,-0.1988410949707031,-0.1655220985412598,-0.1630783081054688,-0.3317296504974365,-0.5640685558319092,-0.7520020008087158,-0.863879919052124,-0.8632838726043701,-0.87699294090271,-0.9334683418273926,-0.9591281414031982,-0.9307861328125,-0.8623301982879639,-0.8475780487060547,-0.9440481662750244,-1.135736703872681,-1.28290057182312,-1.289576292037964,-1.201152801513672,-1.092582941055298,-1.022040843963623,-1.083731651306152,-1.175194978713989,-1.14712119102478,-0.9898841381072998,-0.79384446144104,-0.6372630596160889,-0.6339848041534424,-0.7640421390533447,-0.8521676063537598,-0.8112192153930664,-0.6425976753234863,-0.4137158393859863,-0.2907216548919678,-0.2832114696502686,-0.2704858779907227,-0.2034008502960205,-0.1177191734313965,-0.08308887481689453,-0.09214878082275391,-0.148087739944458,-0.194549560546875,-0.2276003360748291,-0.2355873584747314,-0.2227127552032471,-0.2149641513824463,-0.2065002918243408,-0.1661479473114014,-0.1302957534790039,-0.2016127109527588,-0.3989636898040771,-0.6368458271026611,-0.8799135684967041,-1.084029674530029,-1.20505690574646,-1.311451196670532,-1.327842473983765,-1.315861940383911,-1.273751258850098,-1.061916351318359,-0.8389055728912354,-0.8150041103363037,-0.9018182754516602,-1.002997159957886,-1.014202833175659,-0.9167194366455078,-0.9115636348724365,-1.044511795043945,-1.073092222213745,-0.9443163871765137,-0.8102655410766602,-0.8532404899597168,-0.9775161743164062,-1.022249460220337,-0.9640753269195557,-0.8954703807830811,-0.8785426616668701,-0.887751579284668,-0.9080767631530762,-0.9016990661621094,-0.9180307388305664,-0.866323709487915,-0.6958842277526855,-0.4776418209075928,-0.2071857452392578,-0.02145767211914062,-0.02279877662658691,-0.1613497734069824,-0.3519952297210693,-0.4758834838867188,-0.6325244903564453,-0.8691847324371338,-0.9829103946685791,-0.9452700614929199,-0.876009464263916,-0.6796121597290039,-0.5051493644714355,-0.4372596740722656,-0.3647506237030029,-0.3146231174468994,-0.3645122051239014,-0.4014968872070312,-0.3626644611358643,-0.3778338432312012,-0.4999637603759766,-0.6122291088104248,-0.6234049797058105,-0.5864799022674561,-0.4768967628479004,-0.3572702407836914,-0.2927780151367188,-0.1761019229888916,-0.05504488945007324,-0.002831220626831055,0.1403391361236572,0.3623664379119873,0.4035532474517822,0.3070533275604248,0.165104866027832,0.08308887481689453,0.1373291015625,0.2543330192565918,0.2844929695129395,0.2681314945220947,0.2899765968322754,0.3029406070709229,0.1792311668395996,2.980232238769531e-05,-0.05242228507995605,-0.001162290573120117,0.03409385681152344,0.06499886512756348,0.0502467155456543,0.06687641143798828,0.09745359420776367,-0.03379583358764648,-0.1944601535797119,-0.2214610576629639,-0.1614689826965332,-0.1677274703979492,-0.2904832363128662,-0.4932582378387451,-0.6276071071624756,-0.697016716003418,-0.8223056793212891,-0.8285641670227051,-0.6039142608642578,-0.2852678298950195,0.01230835914611816,0.2851784229278564,0.3705322742462158,0.2709627151489258,0.1535713672637939,0.001966953277587891,-0.1614093780517578,-0.3285408020019531,-0.5424916744232178,-0.7858872413635254,-0.9218156337738037,-0.8156895637512207,-0.6362199783325195,-0.4890859127044678,-0.29793381690979,-0.1218020915985107,0.07116794586181641,0.3947317600250244,0.62522292137146,0.6609261035919189,0.6465315818786621,0.5818605422973633,0.4426836967468262,0.2758502960205078,0.1402497291564941,0.06049871444702148,0.0464320182800293,0.0782310962677002,0.1425743103027344,0.2447962760925293,0.3066360950469971,0.272214412689209,0.1573562622070312,-0.02661347389221191,-0.2013146877288818,-0.2137124538421631,-0.1314878463745117,-0.1279711723327637,-0.2252459526062012,-0.3300607204437256,-0.5050301551818848,-0.608295202255249,-0.4637539386749268,-0.2531707286834717,-0.1908242702484131,-0.3158152103424072,-0.4952847957611084,-0.5481839179992676,-0.4414618015289307,-0.2533793449401855,-0.2606511116027832,-0.4512667655944824,-0.5682706832885742,-0.5734860897064209,-0.4140138626098633,-0.1154243946075439,0.1549720764160156,0.3303885459899902,0.3644227981567383,0.2211034297943115,0.1550912857055664,0.3727972507476807,0.7777214050292969,1.14673376083374,1.39424204826355,1.42863392829895,1.233369112014771,1.072436571121216,1.08647346496582,1.09294056892395,1.095026731491089,1.13251805305481,0.9492933750152588,0.6769001483917236,0.5784928798675537,0.638127326965332,0.6847083568572998,0.6744265556335449,0.6558001041412354,0.6628334522247314,0.6308257579803467,0.5307793617248535,0.333249568939209,0.08547306060791016,-0.168532133102417,-0.362396240234375,-0.4534125328063965,-0.4336237907409668,-0.3834664821624756,-0.408560037612915,-0.4457235336303711,-0.3930926322937012,-0.2241432666778564,-0.03963708877563477,0.1302361488342285,0.2976357936859131,0.4093348979949951,0.4912018775939941,0.5315840244293213,0.5384087562561035,0.483781099319458,0.3306865692138672,0.07903575897216797,-0.11405348777771,-0.09942054748535156,0.1457035541534424,0.4770457744598389,0.6996989250183105,0.7853806018829346,0.7654130458831787,0.6763935089111328,0.5926191806793213,0.6011128425598145,0.7377266883850098,0.9011030197143555,0.9891688823699951,0.9129047393798828,0.7102787494659424,0.5628764629364014,0.5404949188232422,0.6228983402252197,0.7587969303131104,0.9082257747650146,1.050174236297607,1.119434833526611,1.136302947998047,1.132220029830933,1.173794269561768,1.295179128646851,1.363605260848999,1.405537128448486,1.497149467468262,1.565933227539062,1.55302882194519,1.628637313842773,1.742780208587646,1.692503690719604,1.486241817474365,1.285403966903687,1.279503107070923,1.404792070388794,1.469254493713379,1.474499702453613,1.550525426864624,1.726508140563965,1.922309398651123,2.098351716995239,2.123117446899414,1.794159412384033,1.215040683746338,0.7125139236450195,0.5138814449310303,0.5483925342559814,0.5764663219451904,0.4299581050872803,0.1632869243621826,-0.09238719940185547,-0.2424418926239014,-0.2232193946838379,-0.1234114170074463,-0.1104176044464111,-0.1132786273956299,-0.02741813659667969,0.1745820045471191,0.3643333911895752,0.4020333290100098,0.2761185169219971,0.08767843246459961,0.03907084465026855,0.1041293144226074,0.2371072769165039,0.3397762775421143,0.3584623336791992,0.279843807220459,0.1727640628814697,0.08299946784973145,0.07134675979614258,0.2185404300689697,0.4037022590637207,0.5338191986083984,0.5706548690795898,0.548243522644043,0.4981160163879395,0.4415810108184814,0.4495084285736084,0.6194114685058594,0.8165240287780762,0.9003579616546631,0.81595778465271,0.7120966911315918,0.6778836250305176,0.7188320159912109,0.7043778896331787,0.5733370780944824,0.4447102546691895,0.4024207592010498,0.4977881908416748,0.6732046604156494,0.7649064064025879,0.7593929767608643,0.729978084564209,0.6843805313110352,0.620722770690918,0.621497631072998,0.6730556488037109,0.6700456142425537,0.5564093589782715,0.3671646118164062,0.2256631851196289,0.2744793891906738,0.4030168056488037,0.4843771457672119,0.3595352172851562,0.09956955909729004,-0.05573034286499023,-0.06446242332458496,-0.04735589027404785,-0.06726384162902832,-0.1343190670013428,-0.1352429389953613,-0.08755922317504883,-0.08469820022583008,-0.1516044139862061,-0.325322151184082,-0.5326271057128906,-0.6913542747497559,-0.8131861686706543,-0.9132921695709229,-1.016974449157715,-1.085966825485229,-1.158177852630615,-1.252830028533936,-1.34432315826416,-1.429945230484009,-1.446962356567383,-1.44040584564209,-1.47700309753418,-1.510322093963623,-1.411795616149902,-1.248866319656372,-1.126080751419067,-1.070290803909302,-1.122325658798218,-1.161843538284302,-1.124650239944458,-0.9925365447998047,-0.966876745223999,-1.009732484817505,-1.050382852554321,-1.132547855377197,-1.288831233978271,-1.367032527923584,-1.330256462097168,-1.222521066665649,-1.138269901275635,-1.185894012451172,-1.2320876121521,-1.146912574768066,-0.90789794921875,-0.6597042083740234,-0.5082488059997559,-0.5075037479400635,-0.4808306694030762,-0.3069639205932617,-0.1305043697357178,-0.03671646118164062,0.01299381256103516,0.04312396049499512,0.07346272468566895,0.1125633716583252,0.1278221607208252,0.07918477058410645,-0.02005696296691895,-0.1294910907745361,-0.2174079418182373,-0.3337860107421875,-0.3214478492736816,-0.1650452613830566,-0.1044869422912598,-0.2324581146240234,-0.376582145690918,-0.4797875881195068,-0.6273984909057617,-0.7932484149932861,-0.9600520133972168,-1.020818948745728,-1.082509756088257,-1.232415437698364,-1.347601413726807,-1.32790207862854,-1.252502202987671,-1.10095739364624,-0.8240640163421631,-0.4901885986328125,-0.2943575382232666,-0.3382861614227295,-0.4594027996063232,-0.4768967628479004,-0.4435479640960693,-0.5354881286621094,-0.7267296314239502,-0.8489787578582764,-0.9388625621795654,-1.010775566101074,-1.04948878288269,-1.094400882720947,-1.089274883270264,-1.074552536010742,-1.079857349395752,-1.054227352142334,-0.8829236030578613,-0.5546212196350098,-0.231325626373291,-0.02911686897277832,0.171959400177002,0.4673302173614502,0.6265044212341309,0.4738867282867432,0.1808404922485352,-0.07539987564086914,-0.2950429916381836,-0.5625486373901367,-0.9258389472961426,-1.264125108718872,-1.581758260726929,-1.795381307601929,-1.833051443099976,-1.747786998748779,-1.488924026489258,-1.137346029281616,-0.8707940578460693,-0.7909238338470459,-0.8103549480438232,-0.826716423034668,-0.774681568145752,-0.729680061340332,-0.8531808853149414,-1.09294056892395,-1.340180635452271,-1.51216983795166,-1.541048288345337,-1.402407884597778,-1.193135976791382,-1.0337233543396,-1.001805067062378,-1.059174537658691,-1.104474067687988,-1.010119915008545,-0.8258521556854248,-0.6056129932403564,-0.474393367767334,-0.4892647266387939,-0.566333532333374,-0.6393492221832275,-0.6123185157775879,-0.5008280277252197,-0.3290176391601562,-0.1877844333648682,-0.2457797527313232,-0.5388259887695312,-0.841677188873291,-1.050829887390137,-1.203089952468872,-1.413136720657349,-1.543700695037842,-1.559019088745117,-1.469969749450684,-1.248955726623535,-0.9288191795349121,-0.6075799465179443,-0.4613399505615234,-0.531315803527832,-0.7148385047912598,-0.881195068359375,-0.9242892265319824,-0.845491886138916,-0.7576644420623779,-0.791698694229126,-0.8697509765625,-0.8682012557983398,-0.780642032623291,-0.6083846092224121,-0.4332363605499268,-0.3417134284973145,-0.3545582294464111,-0.4538297653198242,-0.6113946437835693,-0.8093118667602539,-0.9514391422271729,-1.041829586029053,-1.027226448059082,-0.9658336639404297,-0.8858442306518555,-0.8600950241088867,-0.9419918060302734,-1.145690679550171,-1.300454139709473,-1.379102468490601,-1.437902450561523,-1.486837863922119,-1.599699258804321,-1.765608787536621,-1.85123085975647,-1.830309629440308,-1.744180917739868,-1.717895269393921,-1.807272434234619,-1.823335886001587,-1.748383045196533,-1.695990562438965,-1.772314310073853,-2.036839723587036,-2.352535724639893,-2.505660057067871,-2.435177564620972,-2.28041410446167,-2.180129289627075,-2.222061157226562,-2.346992492675781,-2.462327480316162,-2.496182918548584,-2.341777086257935,-2.022415399551392,-1.700818538665771,-1.485824584960938,-1.374393701553345,-1.30850076675415,-1.217752695083618,-1.122057437896729,-1.015454530715942,-1.011401414871216,-1.086175441741943,-1.122266054153442,-1.048058271408081,-1.009494066238403,-1.016408205032349,-0.9085237979888916,-0.5698502063751221,-0.1434385776519775,0.2020299434661865,0.2966821193695068,0.2368390560150146,0.2366006374359131,0.3278255462646484,0.421375036239624,0.5461275577545166,0.7017254829406738,0.8058845996856689,0.8014440536499023,0.6745457649230957,0.6226003170013428,0.6583034992218018,0.6777346134185791,0.6405413150787354,0.589221715927124,0.573962926864624,0.5893111228942871,0.5733370780944824,0.5965828895568848,0.6075501441955566,0.565260648727417,0.591665506362915,0.679701566696167,0.8707642555236816,1.148223876953125,1.336961984634399,1.383334398269653,1.365095376968384,1.298993825912476,1.125335693359375,0.7835328578948975,0.3521442413330078,0.07745623588562012,-0.001668930053710938,0.06541609764099121,0.1868009567260742,0.2096891403198242,0.152587890625,0.1188218593597412,0.1280605792999268,0.2682507038116455,0.3985166549682617,0.4342198371887207,0.3600120544433594,0.2131462097167969,0.08949637413024902,0.03066658973693848,0.02014636993408203,0.02473592758178711,-0.09456276893615723,-0.3032684326171875,-0.4210770130157471,-0.3777146339416504,-0.1298487186431885,0.2046525478363037,0.3417134284973145,0.2179741859436035,-0.02801418304443359,-0.1079738140106201,0.05865097045898438,0.3212690353393555,0.4598498344421387,0.5054175853729248,0.5848705768585205,0.7255375385284424,0.8502602577209473,0.9505748748779297,1.13186240196228,1.386016607284546,1.470863819122314,1.325160264968872,1.166462898254395,1.233309507369995,1.444607973098755,1.632362604141235,1.743942499160767,1.760244369506836,1.742690801620483,1.798689365386963,1.952379941940308,2.121239900588989,2.172172069549561,2.119392156600952,2.021133899688721,1.978605985641479,2.054989337921143,2.235949039459229,2.423256635665894,2.489596605300903,2.418696880340576,2.12395191192627,1.636356115341187,1.3466477394104,1.379430294036865,1.514345407485962,1.485198736190796,1.275718212127686,1.110076904296875,1.181364059448242,1.390784978866577,1.595377922058105,1.825541257858276,2.001494169235229,2.027362585067749,1.880496740341187,1.728981733322144,1.720964908599854,1.674354076385498,1.540064811706543,1.409471035003662,1.337528228759766,1.282244920730591,1.189053058624268,1.096516847610474,1.088619232177734,1.250177621841431,1.472413539886475,1.566559076309204,1.450479030609131,1.341074705123901,1.379251480102539,1.504570245742798,1.617580652236938,1.648515462875366,1.622527837753296,1.4839768409729,1.238971948623657,1.114934682846069,1.223862171173096,1.472741365432739,1.714080572128296,1.792460680007935,1.715421676635742,1.671344041824341,1.698732376098633,1.656711101531982,1.576811075210571,1.44621729850769,1.21721625328064,0.9994208812713623,0.9143948554992676,0.9958744049072266,1.242339611053467,1.312255859375,1.178056001663208,1.254469156265259,1.61367654800415,1.963257789611816,2.192765474319458,2.282977104187012,2.322912216186523,2.388894557952881,2.377629280090332,2.331554889678955,2.271771430969238,2.213954925537109,2.231985330581665,2.244234085083008,2.214640378952026,2.1933913230896,2.161204814910889,2.141952514648438,1.975029706954956,1.713931560516357,1.616120338439941,1.601934432983398,1.556724309921265,1.485228538513184,1.453399658203125,1.62804126739502,1.960515975952148,1.954168081283569,1.509130001068115,1.021623611450195,0.718533992767334,0.5669295787811279,0.5335211753845215,0.622481107711792,0.7729530334472656,0.8503198623657227,0.6511807441711426,0.3654956817626953,0.3116428852081299,0.5078315734863281,0.6681084632873535,0.7111728191375732,0.8560419082641602,1.059293746948242,1.012802124023438,0.6949007511138916,0.2915561199188232,0.03463029861450195,0.01314282417297363,0.03206729888916016,0.154346227645874,0.4990100860595703,0.9084939956665039,1.159965991973877,1.277923583984375,1.587033271789551,2.15575098991394,2.461791038513184,2.210646867752075,1.675277948379517,1.222878694534302,0.9551048278808594,0.7766485214233398,0.8041560649871826,1.031726598739624,1.363158226013184,1.566886901855469,1.528322696685791,1.393139362335205,1.621752977371216,2.087235450744629,2.231419086456299,2.024412155151367,1.744180917739868,1.532107591629028,1.273036003112793,1.032263040542603,0.9489059448242188,0.9664297103881836,0.938117504119873,1.004576683044434,1.300662755966187,1.739978790283203,2.104878425598145,2.193212509155273,2.063006162643433,1.881420612335205,1.665771007537842,1.511573791503906,1.530379056930542,1.646637916564941,1.674115657806396,1.510441303253174,1.302510499954224,1.061856746673584,0.8675158023834229,0.7450282573699951,0.6809234619140625,0.5864202976226807,0.52681565284729,0.5201995372772217,0.5308091640472412,0.6284415721893311,0.8395016193389893,1.062959432601929,1.095205545425415,0.8057355880737305,0.3756284713745117,0.1148581504821777,0.1739561557769775,0.3785192966461182,0.4545152187347412,0.3074705600738525,0.08866190910339355,-0.06693601608276367,-0.05513429641723633,0.129014253616333,0.3614127635955811,0.4663169384002686,0.3749728202819824,0.2995133399963379,0.3722906112670898,0.4589557647705078,0.5681812763214111,0.6465911865234375,0.6018280982971191,0.4344582557678223,0.199049711227417,-0.07623434066772461,-0.2870857715606689,-0.3072023391723633,-0.2543628215789795,-0.1620650291442871,-0.07370114326477051,-0.09682774543762207,-0.2245008945465088,-0.462651252746582,-0.697016716003418,-0.8276998996734619,-0.8589625358581543,-0.7333457469940186,-0.5481541156768799,-0.5688369274139404,-0.7508397102355957,-0.8671879768371582,-0.6939172744750977,-0.3368258476257324,-0.07483363151550293,0.1398324966430664,0.4069209098815918,0.7328391075134277,0.8820891380310059,0.6098449230194092,0.1186132431030273,-0.1758337020874023,-0.4036128520965576,-0.638812780380249,-0.6708502769470215,-0.4798471927642822,-0.4514455795288086,-0.6904006004333496,-0.8435845375061035,-0.7974803447723389,-0.726848840713501,-0.652998685836792,-0.3538429737091064,0.05206465721130371,0.1172125339508057,-0.278860330581665,-0.6840229034423828,-0.6473064422607422,-0.158458948135376,0.1898109912872314,-0.01496076583862305,-0.4079341888427734,-0.6310641765594482,-0.5600154399871826,-0.2572238445281982,0.02568960189819336,0.0286102294921875,-0.2610981464385986,-0.6344616413116455,-0.9220540523529053,-0.9359419345855713,-0.5400478839874268,-0.1170039176940918,0.01686811447143555,0.05173683166503906,0.1417100429534912,0.2760887145996094,0.3960728645324707,0.4790425300598145,0.4579424858093262,0.2144277095794678,-0.1107752323150635,-0.2765357494354248,-0.30556321144104,-0.2861618995666504,-0.2270042896270752,-0.1627802848815918,-0.237196683883667,-0.5308389663696289,-0.9460747241973877,-1.281529664993286,-1.391619443893433,-1.334697008132935,-1.287847757339478,-1.34006142616272,-1.423567533493042,-1.449108123779297,-1.442700624465942,-1.409024000167847,-1.344680786132812,-1.270025968551636,-1.189947128295898,-1.119107007980347,-1.065224409103394,-1.118928194046021,-1.341372728347778,-1.599311828613281,-1.715302467346191,-1.730471849441528,-1.756250858306885,-1.726359128952026,-1.62053108215332,-1.526921987533569,-1.523733139038086,-1.594036817550659,-1.654922962188721,-1.600414514541626,-1.547485589981079,-1.640379428863525,-1.795858144760132,-1.875579357147217,-1.793086528778076,-1.614898443222046,-1.42979621887207,-1.348167657852173,-1.351147890090942,-1.258343458175659,-1.004964113235474,-0.9175240993499756,-1.01393461227417,-1.180171966552734,-1.282840967178345,-1.232177019119263,-1.113682985305786,-1.087337732315063,-1.182705163955688,-1.281470060348511,-1.390188932418823,-1.564651727676392,-1.648962497711182,-1.639485359191895,-1.679480075836182,-1.695424318313599,-1.667320728302002,-1.76924467086792,-1.912564039230347,-1.962006092071533,-1.990526914596558,-2.091884613037109,-2.229064702987671,-2.383142709732056,-2.545833587646484,-2.718955278396606,-2.802222967147827,-2.834349870681763,-2.838790416717529,-2.730488777160645,-2.568811178207397,-2.343893051147461,-2.151370048522949,-2.038002014160156,-1.97938084602356,-1.944005489349365,-1.872330904006958,-1.746803522109985,-1.578032970428467,-1.334577798843384,-1.069039106369019,-0.86250901222229,-0.7586181163787842,-0.7124841213226318,-0.7540881633758545,-0.9042918682098389,-1.07613205909729,-1.171976327896118,-1.27488374710083,-1.388043165206909,-1.433223485946655,-1.419544219970703,-1.372694969177246,-1.347661018371582,-1.367866992950439,-1.385718584060669,-1.442611217498779,-1.574963331222534,-1.737266778945923,-1.806437969207764,-1.693636178970337,-1.524746417999268,-1.349806785583496,-1.197636127471924,-1.109093427658081,-1.119881868362427,-1.250922679901123,-1.546680927276611,-1.783132553100586,-1.764178276062012,-1.604676246643066,-1.48347020149231,-1.420557498931885,-1.264661550521851,-0.933527946472168,-0.6041824817657471,-0.4854202270507812,-0.5190074443817139,-0.4873573780059814,-0.3795325756072998,-0.2245604991912842,-0.08687376976013184,0.04497170448303223,0.2014636993408203,0.2067685127258301,0.02282857894897461,-0.0762641429901123,-0.01358985900878906,0.1362860202789307,0.2680122852325439,0.3182590007781982,0.2969801425933838,0.3639161586761475,0.5000829696655273,0.5059540271759033,0.3806054592132568,0.3260970115661621,0.2865791320800781,0.2467036247253418,0.2794265747070312,0.3598630428314209,0.3168284893035889,0.02133846282958984,-0.3232955932617188,-0.3944337368011475,-0.2491474151611328,-0.1763403415679932,-0.3491044044494629,-0.8035004138946533,-1.213371753692627,-1.220226287841797,-0.9289383888244629,-0.6403625011444092,-0.4625618457794189,-0.3977417945861816,-0.3891587257385254,-0.3675520420074463,-0.223010778427124,0.07915496826171875,0.272601842880249,0.188976526260376,-0.07325410842895508,-0.2606809139251709,-0.2119839191436768,0.02646446228027344,0.2184212207794189,0.2330541610717773,0.1405775547027588,-0.1009106636047363,-0.4777610301971436,-0.7187128067016602,-0.5828738212585449,-0.09936094284057617,0.4123449325561523,0.589519739151001,0.5322396755218506,0.5238950252532959,0.5823075771331787,0.635296106338501,0.7410645484924316,0.8997917175292969,1.052528619766235,1.097232103347778,1.016914844512939,1.047730445861816,1.141399145126343,1.105606555938721,0.8976757526397705,0.5656182765960693,0.3361999988555908,0.3609061241149902,0.5029439926147461,0.693202018737793,0.9767115116119385,1.221835613250732,1.443982124328613,1.697748899459839,1.921027898788452,2.049386501312256,1.994043588638306,1.807630062103271,1.694828271865845,1.662671566009521,1.549988985061646,1.266151666641235,0.9585320949554443,0.8177459239959717,0.8354783058166504,0.8660554885864258,0.86212158203125,0.7569193840026855,0.6347596645355225,0.6794631481170654,0.7465481758117676,0.6726086139678955,0.5494654178619385,0.5168318748474121,0.5168318748474121,0.5626380443572998,0.6940662860870361,0.8780956268310547,0.8089244365692139,0.3353655338287354,-0.1786351203918457,-0.3352761268615723,-0.2055764198303223,-0.03412365913391113,-0.01472234725952148,-0.1770257949829102,-0.3861188888549805,-0.5668401718139648,-0.6431639194488525,-0.6667077541351318,-0.6334781646728516,-0.4945993423461914,-0.471651554107666,-0.6737709045410156,-0.7474720478057861,-0.6288588047027588,-0.4587769508361816,-0.3931820392608643,-0.5100369453430176,-0.6907880306243896,-0.8661448955535889,-1.025468111038208,-0.8420050144195557,-0.2738237380981445,0.2807974815368652,0.6996095180511475,0.9246766567230225,0.9797215461730957,1.053392887115479,1.21992826461792,1.27825140953064,1.15540623664856,1.05893611907959,1.24475359916687,1.640379428863525,1.769930124282837,1.491695642471313,1.168966293334961,1.10781192779541,1.317739486694336,1.52859091758728,1.453578472137451,1.131385564804077,0.7507503032684326,0.5536973476409912,0.7459819316864014,1.186132431030273,1.636892557144165,1.799046993255615,1.565366983413696,1.282751560211182,1.10393762588501,0.9604990482330322,0.8191764354705811,0.6993710994720459,0.6604492664337158,0.560462474822998,0.3053247928619385,0.08991360664367676,0.06496906280517578,0.07125735282897949,0.03087520599365234,-0.03945827484130859,-0.1099109649658203,-0.09450316429138184,0.07167458534240723,0.3539621829986572,0.6112456321716309,0.6041228771209717,0.3144741058349609,-0.1215934753417969,-0.4790425300598145,-0.5560815334320068,-0.4363059997558594,-0.190436840057373,0.107884407043457,0.2801716327667236,0.3920495510101318,0.5326569080352783,0.603795051574707,0.557243824005127,0.3878772258758545,0.12168288230896,-0.08741021156311035,-0.103294849395752,0.001847743988037109,0.1627504825592041,0.2345144748687744,0.0979006290435791,-0.0374913215637207,-0.1030266284942627,-0.100255012512207,0.07262825965881348,0.3072917461395264,0.514686107635498,0.660240650177002,0.7426440715789795,0.7252097129821777,0.6752312183380127,0.6425380706787109,0.6005465984344482,0.5520880222320557,0.4498958587646484,0.3219544887542725,0.1489818096160889,0.001817941665649414,0.02130866050720215,0.1478791236877441,0.2113580703735352,0.2632737159729004,0.3858208656311035,0.5463361740112305,0.6529688835144043,0.5806982517242432,0.3449022769927979,0.1182258129119873,-0.1089870929718018,-0.3339648246765137,-0.4433691501617432,-0.3830790519714355,-0.2419948577880859,-0.08434057235717773,0.05882978439331055,0.2048611640930176,0.4672706127166748,0.713646411895752,0.7429420948028564,0.5569159984588623,0.271916389465332,-0.01341104507446289,-0.1726448535919189,-0.2024173736572266,-0.08574128150939941,0.008016824722290039,0.04026293754577637,0.006377696990966797,-0.02235174179077148,0.05638599395751953,0.1947581768035889,0.3413856029510498,0.4368424415588379,0.4124641418457031,0.364452600479126,0.2612471580505371,0.04732608795166016,-0.1313090324401855,-0.2400577068328857,-0.1860857009887695,0.0311434268951416,0.3418624401092529,0.665813684463501,0.8384883403778076,0.5912184715270996,0.140756368637085,-0.2186596393585205,-0.49629807472229,-0.6836950778961182,-0.8729696273803711,-1.031339168548584,-1.026660203933716,-0.8927881717681885,-0.6867051124572754,-0.4875361919403076,-0.4519522190093994,-0.64849853515625,-0.9556412696838379,-1.325756311416626,-1.692265272140503,-1.913785934448242,-1.97938084602356,-2.045214176177979,-2.181023359298706,-2.303779125213623,-2.280652523040771,-2.078413963317871,-1.775175333023071,-1.488089561462402,-1.366406679153442,-1.416623592376709,-1.482069492340088,-1.573741436004639,-1.723736524581909,-1.85924768447876,-1.970082521438599,-2.01416015625,-1.847445964813232,-1.594364643096924,-1.358181238174438,-1.191139221191406,-1.200854778289795,-1.326471567153931,-1.39695405960083,-1.294612884521484,-0.9340345859527588,-0.5661845207214355,-0.4526078701019287,-0.5307197570800781,-0.6848573684692383,-0.7754862308502197,-0.6691813468933105,-0.4138648509979248,-0.265955924987793,-0.3573000431060791,-0.6421506404876709,-0.8153319358825684,-0.7005631923675537,-0.5593001842498779,-0.6110072135925293,-0.8390545845031738,-0.948101282119751,-0.7448792457580566,-0.4442334175109863,-0.3658831119537354,-0.5500912666320801,-0.8472204208374023,-1.147150993347168,-1.488357782363892,-1.842230558395386,-1.92570686340332,-1.816093921661377,-1.741021871566772,-1.697391271591187,-1.67354941368103,-1.572310924530029,-1.404672861099243,-1.336932182312012,-1.263231039047241,-1.001507043838501,-0.7532835006713867,-0.6015002727508545,-0.4863440990447998,-0.4025101661682129,-0.3522038459777832,-0.3845691680908203,-0.5407929420471191,-0.7118880748748779,-0.8255243301391602,-0.8487403392791748,-0.8591413497924805,-0.8706152439117432,-0.8476972579956055,-0.7451176643371582,-0.5746185779571533,-0.3613531589508057,-0.2433359622955322,-0.4311501979827881,-0.8994340896606445,-1.36980414390564,-1.695364713668823,-1.84941291809082,-1.853436231613159,-1.785248517990112,-1.713186502456665,-1.579999923706055,-1.386165618896484,-1.281648874282837,-1.34316086769104,-1.519680023193359,-1.666665077209473,-1.691341400146484,-1.681387424468994,-1.713842153549194,-1.825422048568726,-2.063751220703125,-2.372711896896362,-2.585738897323608,-2.659827470779419,-2.691119909286499,-2.743273973464966,-2.672851085662842,-2.376973628997803,-1.892238855361938,-1.343369483947754,-0.9337663650512695,-0.7873773574829102,-0.7669925689697266,-0.6954073905944824,-0.5581080913543701,-0.3911852836608887,-0.2738535404205322,-0.2296864986419678,-0.2358853816986084,-0.1701712608337402,-0.05161762237548828,0.02610683441162109,0.0101625919342041,-0.03102421760559082,-0.0584721565246582,0.01895427703857422,0.1880824565887451,0.2522468566894531,0.269085168838501,0.3093183040618896,0.2694427967071533,0.3792047500610352,0.6738007068634033,0.8985698223114014,0.9346604347229004,0.6664097309112549,0.3387033939361572,0.2137124538421631,0.2273321151733398,0.2450048923492432,0.1388490200042725,0.002562999725341797,0.09667873382568359,0.3437399864196777,0.5532801151275635,0.7492899894714355,0.7803142070770264,0.6419122219085693,0.516742467880249,0.4346370697021484,0.4682242870330811,0.5771517753601074,0.6362795829772949,0.5874931812286377,0.3917515277862549,0.1926422119140625,0.1729428768157959,0.4585981369018555,1.070380210876465,1.655280590057373,1.933872699737549,1.84553861618042,1.520544290542603,1.15501880645752,0.7495880126953125,0.3549456596374512,0.1335442066192627,0.04494190216064453,-0.1170635223388672,-0.3180801868438721,-0.5109906196594238,-0.5923211574554443,-0.4933476448059082,-0.3246665000915527,-0.2513229846954346,-0.2890825271606445,-0.4013478755950928,-0.4881918430328369,-0.5342662334442139,-0.5422830581665039,-0.4857480525970459,-0.430375337600708,-0.4843771457672119,-0.4062354564666748,-0.01958012580871582,0.3747642040252686,0.6538033485412598,0.8909702301025391,1.054823398590088,1.074165105819702,1.050174236297607,1.038730144500732,1.00630521774292,0.9202361106872559,0.7973313331604004,0.84686279296875,1.137048006057739,1.59946084022522,2.09808349609375,2.487599849700928,2.756774425506592,2.893209457397461,2.814799547195435,2.501398324966431,2.201616764068604,2.10261344909668,2.144128084182739,2.161383628845215,2.153754234313965,2.018630504608154,1.839250326156616,1.669138669967651,1.464039087295532,1.273423433303833,1.253068447113037,1.24514102935791,1.092076301574707,1.067668199539185,1.200646162033081,1.042753458023071,0.7981956005096436,0.8811354637145996,0.9570121765136719,0.830918550491333,0.532299280166626,0.1209080219268799,-0.1429617404937744,-0.1102089881896973,0.07700920104980469,0.3004670143127441,0.4569590091705322,0.5183815956115723,0.3836750984191895,0.1478493213653564,-0.01478195190429688,0.02679228782653809,0.1639127731323242,0.3459751605987549,0.5414187908172607,0.7678866386413574,0.9313821792602539,0.9486973285675049,0.8151233196258545,0.4853010177612305,0.1212358474731445,0.02110004425048828,0.1305639743804932,0.2615749835968018,0.3722012042999268,0.3920495510101318,0.4051923751831055,0.3340840339660645,0.133216381072998,-0.04532933235168457,-0.05230307579040527,0.03197789192199707,-0.002086162567138672,-0.1693964004516602,-0.2859234809875488,-0.2036094665527344,0.01120567321777344,0.1699626445770264,0.3434121608734131,0.6162822246551514,0.968635082244873,1.411199569702148,1.781761646270752,1.812845468521118,1.536458730697632,1.234501600265503,1.018822193145752,0.858306884765625,0.7178187370300293,0.5170702934265137,0.2225041389465332,0.009804964065551758,-0.003814697265625,0.1717805862426758,0.4718303680419922,0.7098913192749023,0.7793903350830078,0.7995367050170898,0.8401870727539062,0.8828938007354736,1.030325889587402,1.187801361083984,1.301109790802002,1.384526491165161,1.398801803588867,1.443654298782349,1.528024673461914,1.576662063598633,1.467347145080566,1.198709011077881,0.8800625801086426,0.5870461463928223,0.405728816986084,0.4489719867706299,0.552058219909668,0.5622804164886475,0.5440711975097656,0.3088414669036865,-0.05680322647094727,-0.3039538860321045,-0.3810524940490723,-0.3027915954589844,-0.1643002033233643,-0.08970499038696289,-0.0565946102142334,-0.09298324584960938,-0.1042187213897705,-0.02649426460266113,-0.03850460052490234,-0.1901090145111084,-0.3296732902526855,-0.379413366317749,-0.2776980400085449,-0.119626522064209,-0.1124143600463867,-0.2273023128509521,-0.3317892551422119,-0.3029704093933105,-0.162661075592041,-0.04827976226806641,0.001668930053710938,-0.04589557647705078,-0.2294182777404785,-0.4238784313201904,-0.4820823669433594,-0.4247128963470459,-0.2388954162597656,0.03808736801147461,0.3215372562408447,0.4693269729614258,0.3834068775177002,0.1273155212402344,-0.151515007019043,-0.2145767211914062,-0.01630187034606934,0.1475811004638672,0.05570054054260254,-0.1411736011505127,-0.2353489398956299,-0.1507997512817383,0.05859136581420898,0.1942813396453857,0.08252263069152832,-0.1636147499084473,-0.3954768180847168,-0.5462169647216797,-0.5940496921539307,-0.4816651344299316,-0.4059672355651855,-0.3893375396728516,-0.3206133842468262,-0.2115964889526367,0.03725290298461914,0.3378689289093018,0.4794597625732422,0.5358457565307617,0.6678998470306396,0.9269416332244873,1.3141930103302,1.735210418701172,2.023905515670776,2.101689577102661,2.062946557998657,2.110272645950317,2.279698848724365,2.412348985671997,2.333313226699829,2.023041248321533,1.883715391159058,2.018392086029053,2.114951610565186,2.151846885681152,2.114027738571167,1.967430114746094,2.067089080810547,2.331078052520752,2.294838428497314,1.877129077911377,1.386076211929321,1.086801290512085,0.8785426616668701,0.7408559322357178,0.7755160331726074,0.9438693523406982,1.097410917282104,1.090884208679199,0.9896755218505859,0.9878277778625488,0.9961128234863281,0.7758140563964844,0.3926455974578857,0.03251433372497559,-0.1792311668395996,-0.2279877662658691,-0.3400743007659912,-0.5311667919158936,-0.5869865417480469,-0.339895486831665,0.1427233219146729,0.497281551361084,0.5507469177246094,0.392526388168335,0.3358423709869385,0.5952119827270508,0.9478330612182617,1.113772392272949,1.046359539031982,0.9662210941314697,1.169472932815552,1.402795314788818,1.361757516860962,1.021862030029297,0.6669461727142334,0.554502010345459,0.6594955921173096,0.8717179298400879,1.040130853652954,1.019418239593506,0.8880496025085449,0.796198844909668,0.8197426795959473,0.8568167686462402,0.7884800434112549,0.6886720657348633,0.6429553031921387,0.5508065223693848,0.5045235157012939,0.5189776420593262,0.6394386291503906,0.9198486804962158,1.072704792022705,1.024901866912842,0.9631514549255371,0.9562671184539795,0.9346902370452881,0.9187757968902588,0.8020401000976562,0.5103349685668945,0.1160502433776855,-0.1824498176574707,-0.3333985805511475,-0.4344284534454346,-0.4708766937255859,-0.4665553569793701,-0.4612505435943604,-0.4050135612487793,-0.3605484962463379,-0.3589987754821777,-0.3751814365386963,-0.3494620323181152,-0.3432035446166992,-0.3390014171600342,-0.2585351467132568,-0.1676380634307861,-0.124126672744751,-0.2166032791137695,-0.3366172313690186,-0.1850128173828125,0.1861751079559326,0.5457699298858643,0.8581578731536865,0.9566843509674072,0.7847845554351807,0.5924701690673828,0.5366206169128418,0.5567669868469238,0.5682110786437988,0.5109310150146484,0.3172159194946289,0.05128979682922363,0.06175041198730469,0.4414618015289307,0.8947849273681641,1.248091459274292,1.470506191253662,1.493483781814575,1.486450433731079,1.514017581939697,1.427948474884033,1.207530498504639,0.9707510471343994,0.7568001747131348,0.5778968334197998,0.3814697265625,0.166088342666626,0.04860758781433105,-0.002533197402954102,-0.1479089260101318,-0.4945993423461914,-0.9789466857910156,-1.360237598419189,-1.557409763336182,-1.707255840301514,-1.826345920562744,-1.927584409713745,-2.130895853042603,-2.294361591339111,-2.21860408782959,-2.006828784942627,-1.719295978546143,-1.513242721557617,-1.537859439849854,-1.652389764785767,-1.791238784790039,-1.900553703308105,-1.877367496490479,-1.900225877761841,-1.935631036758423,-1.817047595977783,-1.614630222320557,-1.378685235977173,-1.18488073348999,-1.229584217071533,-1.451283693313599,-1.731991767883301,-1.864790916442871,-1.608490943908691,-1.174271106719971,-0.9194612503051758,-0.8602440357208252,-0.8871555328369141,-0.8838176727294922,-0.7947981357574463,-0.7367134094238281,-0.6091892719268799,-0.2551078796386719,0.1675784587860107,0.6540119647979736,1.15320086479187,1.434445381164551,1.423656940460205,1.151323318481445,0.8008778095245361,0.6076395511627197,0.5550086498260498,0.5520284175872803,0.5550086498260498,0.5352497100830078,0.5910098552703857,0.7201135158538818,0.7549524307250977,0.6815195083618164,0.54892897605896,0.4273653030395508,0.3760755062103271,0.3286898136138916,0.2534985542297363,0.1483261585235596,-0.03850460052490234,-0.3171265125274658,-0.5492866039276123,-0.6622076034545898,-0.6461739540100098,-0.5905032157897949,-0.6666183471679688,-0.9316802024841309,-1.327425241470337,-1.757442951202393,-2.15950608253479,-2.429008483886719,-2.342253923416138,-1.986086368560791,-1.74790620803833,-1.762717962265015,-1.799106597900391,-1.72656774520874,-1.646608114242554,-1.716405153274536,-1.855283975601196,-1.841813325881958,-1.705974340438843,-1.478523015975952,-1.26984715461731,-1.028507947921753,-0.6604790687561035,-0.1766383647918701,0.4552900791168213,1.133233308792114,1.550674438476562,1.541376113891602,1.307755708694458,1.010805368423462,0.7919073104858398,0.6300806999206543,0.4944205284118652,0.5041360855102539,0.6767213344573975,0.8502304553985596,0.8820593357086182,0.8802413940429688,0.8843541145324707,0.913470983505249,0.9584426879882812,0.997394323348999,0.9274780750274658,0.7542967796325684,0.521928071975708,0.1657009124755859,-0.1942217350006104,-0.3390312194824219,-0.3484189510345459,-0.4129409790039062,-0.6484389305114746,-0.976264476776123,-1.16923451423645,-1.263976097106934,-1.383364200592041,-1.518368721008301,-1.735031604766846,-2.03019380569458,-2.309650182723999,-2.446502447128296,-2.353459596633911,-2.067685127258301,-1.813411712646484,-1.631259918212891,-1.409828662872314,-1.304358243942261,-1.45837664604187,-1.679480075836182,-1.638114452362061,-1.339763402938843,-1.082360744476318,-0.9276270866394043,-0.7946491241455078,-0.7728040218353271,-0.8299946784973145,-0.7814466953277588,-0.6738603115081787,-0.8311867713928223,-1.145601272583008,-1.207113265991211,-0.9553432464599609,-0.5684196949005127,-0.2082884311676025,-0.006705522537231445,0.03820657730102539,0.0744163990020752,0.1774132251739502,0.3725290298461914,0.5290508270263672,0.4352331161499023,0.1265406608581543,-0.2515316009521484,-0.5199611186981201,-0.5842149257659912,-0.6904900074005127,-1.054853200912476,-1.439303159713745,-1.678287982940674,-1.735895872116089,-1.738697290420532,-1.896440982818604,-2.094954252243042,-2.192467451095581,-2.152353525161743,-2.091348171234131,-2.007544040679932,-1.998156309127808,-2.079367637634277,-1.999467611312866,-1.751452684402466,-1.619815826416016,-1.596122980117798,-1.615792512893677,-1.616120338439941,-1.556366682052612,-1.618534326553345,-1.814424991607666,-1.955002546310425,-1.987576484680176,-1.813888549804688,-1.336067914962769,-0.6800293922424316,-0.2241730690002441,-0.2139806747436523,-0.3560185432434082,-0.3767311573028564,-0.3231465816497803,-0.2581477165222168,-0.2523660659790039,-0.3116130828857422,-0.3409981727600098,-0.2427399158477783,-0.04568696022033691,0.05438923835754395,-0.1037120819091797,-0.4048943519592285,-0.5309581756591797,-0.4088282585144043,-0.2494156360626221,-0.1753568649291992,-0.2784132957458496,-0.420302152633667,-0.369638204574585,-0.1349747180938721,0.07846951484680176,0.149458646774292,0.1076757907867432,0.2757608890533447,0.6083250045776367,0.8219778537750244,0.9361803531646729,0.8486509323120117,0.6035566329956055,0.2458095550537109,-0.1256763935089111,-0.2017617225646973,0.1291930675506592,0.3276467323303223,0.1316070556640625,-0.1459121704101562,-0.1170635223388672,0.3369450569152832,0.8758604526519775,1.366347074508667,1.73032283782959,1.882582902908325,1.735687255859375,1.367509365081787,1.053899526596069,0.8225142955780029,0.6837844848632812,0.5983412265777588,0.409930944442749,0.1198053359985352,-0.1814961433410645,-0.4420876502990723,-0.630110502243042,-0.7688403129577637,-0.9897053241729736,-1.201719045639038,-1.198410987854004,-0.8785426616668701,-0.4915893077850342,-0.2374649047851562,-0.04848837852478027,0.07024407386779785,0.2584755420684814,0.5081295967102051,0.6729960441589355,0.6508231163024902,0.5271434783935547,0.5282759666442871,0.7818937301635742,1.026719808578491,1.157194375991821,1.208871603012085,1.215159893035889,1.324266195297241,1.528531312942505,1.719623804092407,1.897424459457397,2.097874879837036,2.155303955078125,1.964002847671509,1.739531755447388,1.622170209884644,1.477211713790894,1.235067844390869,1.132220029830933,1.200735569000244,1.105666160583496,0.8130967617034912,0.6317496299743652,0.5557239055633545,0.457465648651123,0.3255009651184082,0.2494752407073975,0.2355277538299561,0.1991093158721924,0.2017617225646973,0.3519654273986816,0.5590617656707764,0.6175339221954346,0.6063282489776611,0.5609393119812012,0.435948371887207,0.2662539482116699,0.1119673252105713,-0.1603066921234131,-0.62522292137146,-0.9070336818695068,-0.7145106792449951,-0.3086328506469727,-0.02598762512207031,0.02884864807128906,0.06136298179626465,0.2720952033996582,0.5717575550079346,0.7188022136688232,0.7830560207366943,0.9616613388061523,1.392245292663574,1.941561698913574,2.445340156555176,2.880394458770752,3.109574317932129,3.012418746948242,2.564072608947754,1.931995153427124,1.515477895736694,1.333385705947876,1.231104135513306,1.278162002563477,1.429706811904907,1.527249813079834,1.492410898208618,1.148372888565063,0.7782578468322754,0.58707594871521,0.5779266357421875,0.6736516952514648,0.634998083114624,0.4287362098693848,0.2660155296325684,0.09384751319885254,-0.1603662967681885,-0.3263354301452637,-0.4717707633972168,-0.6593763828277588,-0.803142786026001,-0.7948577404022217,-0.4860460758209229,0.0006258487701416016,0.2712905406951904,0.1443922519683838,-0.1104772090911865,-0.08171796798706055,0.1537799835205078,0.2801120281219482,0.3618896007537842,0.4118978977203369,0.4101991653442383,0.3487765789031982,0.2067685127258301,0.2637207508087158,0.5563497543334961,0.7472336292266846,0.8655190467834473,1.084566116333008,1.308321952819824,1.373231410980225,1.205861568450928,0.951230525970459,0.8032023906707764,0.7894039154052734,0.7253885269165039,0.4090368747711182,0.1305341720581055,0.1597106456756592,0.3701150417327881,0.4304945468902588,0.1202225685119629,-0.3125667572021484,-0.5682706832885742,-0.5547106266021729,-0.2789199352264404,-0.08296966552734375,-0.07960200309753418,0.09006261825561523,0.5089938640594482,0.9181201457977295,1.096993684768677,0.9371936321258545,0.5136430263519287,-0.03170967102050781,-0.5732476711273193,-0.8072555065155029,-0.6553232669830322,-0.2388954162597656,0.2869963645935059,0.7565915584564209,1.094788312911987,1.2473464012146,1.176297664642334,1.006335020065308,0.7963180541992188,0.7101297378540039,0.9586811065673828,1.278549432754517,1.222729682922363,1.049995422363281,1.141756772994995,1.446843147277832,1.625299453735352,1.41945481300354,0.9808540344238281,0.6216764450073242,0.4477798938751221,0.4956722259521484,0.6915032863616943,0.886082649230957,1.152843236923218,1.280039548873901,1.082360744476318,0.8051395416259766,0.609666109085083,0.4866123199462891,0.3602504730224609,0.2399086952209473,0.2747774124145508,0.5187392234802246,0.8993446826934814,1.319766044616699,1.464039087295532,1.420348882675171,1.429587602615356,1.485943794250488,1.573681831359863,1.614838838577271,1.594901084899902,1.610130071640015,1.467585563659668,1.229166984558105,1.115202903747559,1.180678606033325,1.265853643417358,1.164883375167847,1.056969165802002,1.267135143280029,1.646548509597778,1.920133829116821,2.060085535049438,2.098917961120605,2.175807952880859,2.187579870223999,2.069979906082153,2.076834440231323,2.225369215011597,2.266198396682739,2.136141061782837,2.052009105682373,2.151370048522949,2.199053764343262,2.151012420654297,2.152770757675171,2.223879098892212,2.558499574661255,2.977311611175537,3.050684928894043,2.901434898376465,2.698659896850586,2.453774213790894,2.260893583297729,2.173632383346558,2.001106739044189,1.679956912994385,1.287758350372314,1.081556081771851,1.135498285293579,1.497626304626465,2.132982015609741,2.564549446105957,2.678066492080688,2.779364585876465,2.726227045059204,2.51305103302002,2.451509237289429,2.505302429199219,2.530813217163086,2.404600381851196,2.034366130828857,1.665562391281128,1.572221517562866,1.789867877960205,2.062380313873291,2.096384763717651,2.076417207717896,2.171039581298828,2.344697713851929,2.362489700317383,2.003699541091919,1.582592725753784,1.425802707672119,1.423388719558716,1.470118761062622,1.50001049041748,1.470774412155151,1.39617919921875,1.175433397293091,0.9251236915588379,0.8884072303771973,0.9715259075164795,0.9660124778747559,0.8835494518280029,0.8376240730285645,0.873178243637085,0.9937882423400879,1.037180423736572,0.9550154209136963,0.8197128772735596,0.6933212280273438,0.5752444267272949,0.4509985446929932,0.3505945205688477,0.3594160079956055,0.3627538681030273,0.2171099185943604,0.2409219741821289,0.5452334880828857,0.8199214935302734,0.8567869663238525,0.8176565170288086,0.8470714092254639,1.006036996841431,1.212209463119507,1.279890537261963,1.374781131744385,1.664102077484131,1.99088454246521,2.144455909729004,1.938074827194214,1.651167869567871,1.743525266647339,2.147197723388672,2.422571182250977,2.308070659637451,1.954466104507446,1.746565103530884,1.778960227966309,1.811742782592773,1.681864261627197,1.340270042419434,0.9913444519042969,0.9710490703582764,1.162737607955933,1.381844282150269,1.716583967208862,1.950383186340332,1.837074756622314,1.527845859527588,1.336276531219482,1.337021589279175,1.428842544555664,1.475811004638672,1.338303089141846,1.247137784957886,1.315593719482422,1.503109931945801,1.673996448516846,1.527458429336548,1.153886318206787,0.9726881980895996,1.089125871658325,1.281887292861938,1.36449933052063,1.253306865692139,1.014292240142822,0.776827335357666,0.5820989608764648,0.4387199878692627,0.4545152187347412,0.6620883941650391,0.9355843067169189,1.017868518829346,0.9735226631164551,0.9855926036834717,0.9699165821075439,0.8553266525268555,0.651240348815918,0.2136826515197754,-0.3199875354766846,-0.5380213260650635,-0.4544854164123535,-0.4492998123168945,-0.5533695220947266,-0.5120337009429932,-0.4343092441558838,-0.3729164600372314,-0.2141296863555908,-0.05492568016052246,-0.00998377799987793,-0.05966424942016602,-0.2449154853820801,-0.4495382308959961,-0.5435645580291748,-0.5155205726623535,-0.329822301864624,-0.1218020915985107,0.2109706401824951,0.678330659866333,0.9806156158447266,0.9111464023590088,0.7273852825164795,0.8037388324737549,1.104503870010376,1.378506422042847,1.480340957641602,1.630663871765137,1.940816640853882,2.313107252120972,2.534359693527222,2.41735577583313,2.122551202774048,1.981586217880249,1.864045858383179,1.693844795227051,1.659780740737915,1.703202724456787,1.759797334671021,1.695990562438965,1.393437385559082,1.071721315383911,0.9247660636901855,0.9211897850036621,0.9398162364959717,0.9816586971282959,1.067399978637695,1.065760850906372,0.858992338180542,0.6229281425476074,0.5976259708404541,0.601351261138916,0.4130899906158447,0.1462399959564209,-0.04842877388000488,-0.0438690185546875,0.1153647899627686,0.1218318939208984,0.05206465721130371,0.04154443740844727,0.09244680404663086,0.2398490905761719,0.3528594970703125,0.4104673862457275,0.6082355976104736,0.8066892623901367,0.7893741130828857,0.5809664726257324,0.3711283206939697,0.2576112747192383,0.288844108581543,0.4928112030029297,0.6431639194488525,0.6152093410491943,0.6751716136932373,0.8417069911956787,1.016408205032349,1.421123743057251,2.060890197753906,2.759158611297607,3.27068567276001,3.254890441894531,2.726972103118896,2.110838890075684,1.536130905151367,1.137763261795044,1.075834035873413,1.101791858673096,1.043200492858887,1.129984855651855,1.539409160614014,2.095580101013184,2.397269010543823,2.3784339427948,2.258926630020142,2.178341150283813,2.213656902313232,2.211511135101318,1.893579959869385,1.641660928726196,1.880526542663574,2.376675605773926,2.578914165496826,2.386569976806641,2.072572708129883,1.687735319137573,1.212358474731445,0.7765889167785645,0.5006492137908936,0.437617301940918,0.5483925342559814,0.7389485836029053,0.7388293743133545,0.5428791046142578,0.3116130828857422,0.03373622894287109,-0.2574622631072998,-0.2612173557281494,-0.1210868358612061,-0.08106231689453125,-0.08657574653625488,-0.2294182777404785,-0.5037784576416016,-0.6489455699920654,-0.7039904594421387,-0.6823837757110596,-0.6334483623504639,-0.5524754524230957,-0.3263652324676514,-0.07280707359313965,0.03448128700256348,0.05012750625610352,-0.1818239688873291,-0.6083548069000244,-0.7677376270294189,-0.6865561008453369,-0.6781220436096191,-0.6948411464691162,-0.641167163848877,-0.5028247833251953,-0.2359151840209961,0.2016723155975342,0.6420016288757324,0.9144246578216553,1.136094331741333,1.412689685821533,1.597017049789429,1.635700464248657,1.486420631408691,1.273065805435181,1.153379678726196,1.175403594970703,1.276075839996338,1.432687044143677,1.681268215179443,2.046585083007812,2.395898103713989,2.487838268280029,2.311050891876221,1.989573240280151,1.709997653961182,1.537501811981201,1.520752906799316,1.456648111343384,1.22186541557312,0.8134245872497559,0.3361105918884277,0.04377961158752441,-0.02169609069824219,-0.2728104591369629,-0.7805824279785156,-1.267135143280029,-1.693010330200195,-2.03278660774231,-2.299994230270386,-2.437800168991089,-2.388924360275269,-2.349108457565308,-2.477526664733887,-2.705693244934082,-2.871930599212646,-2.739965915679932,-2.421051263809204,-2.213150262832642,-2.163201570510864,-2.259254455566406,-2.469778060913086,-2.630889415740967,-2.540320158004761,-2.266585826873779,-2.08514928817749,-2.002805471420288,-1.772820949554443,-1.525700092315674,-1.485437154769897,-1.440107822418213,-1.155167818069458,-0.8845627307891846,-0.9082555770874023,-1.20118260383606,-1.538276672363281,-1.77273154258728,-1.779139041900635,-1.465171575546265,-1.093834638595581,-1.109063625335693,-1.476466655731201,-1.767337322235107,-1.661807298660278,-1.441538333892822,-1.615226268768311,-2.15613842010498,-2.634525299072266,-2.678841352462769,-2.362251281738281,-2.076447010040283,-2.100080251693726,-2.370327711105347,-2.564400434494019,-2.706825733184814,-2.889275550842285,-3.090173006057739,-3.092467784881592,-2.991914749145508,-2.973586320877075,-2.81977653503418,-2.508103847503662,-2.312123775482178,-2.415388822555542,-2.888262271881104,-3.573775291442871,-4.081428050994873,-4.102468490600586,-3.747850656509399,-3.380149602890015,-3.34632396697998,-3.591775894165039,-3.737181425094604,-3.530830144882202,-3.17007303237915,-3.079742193222046,-3.313660621643066,-3.590643405914307,-3.577232360839844,-3.355681896209717,-3.211736679077148,-3.240495920181274,-3.318876028060913,-3.442734479904175,-3.49956750869751,-3.29899787902832,-2.844542264938354,-2.240180969238281,-1.910656690597534,-2.161413431167603,-2.687007188796997,-3.185093402862549,-3.462255001068115,-3.416150808334351,-3.260016441345215,-3.018438816070557,-2.603232860565186,-2.188771963119507,-1.889914274215698,-1.694470643997192,-1.671433448791504,-1.880019903182983,-2.215981483459473,-2.424120903015137,-2.347975969314575,-2.256721258163452,-2.39795446395874,-2.663731575012207,-2.676635980606079,-2.341777086257935,-1.817256212234497,-1.380026340484619,-1.304268836975098,-1.410722732543945,-1.454979181289673,-1.520633697509766,-1.723200082778931,-2.057284116744995,-2.542078495025635,-2.824664115905762,-2.808600664138794,-2.68709659576416,-2.456456422805786,-2.099990844726562,-1.844823360443115,-1.74221396446228,-1.872122287750244,-2.303719520568848,-2.836108207702637,-3.164112567901611,-3.047436475753784,-2.661138772964478,-2.32541561126709,-2.062618732452393,-1.848697662353516,-1.870512962341309,-2.020686864852905,-2.021878957748413,-1.783221960067749,-1.392453908920288,-1.235127449035645,-1.435339450836182,-1.78644061088562,-2.121001482009888,-2.410531044006348,-2.650827169418335,-2.861112356185913,-2.987056970596313,-2.902090549468994,-2.654075622558594,-2.383679151535034,-2.166599035263062,-1.999378204345703,-1.79445743560791,-1.525372266769409,-1.314818859100342,-1.405119895935059,-1.750528812408447,-1.806527376174927,-1.426994800567627,-1.077324151992798,-1.148819923400879,-1.469582319259644,-1.608371734619141,-1.372694969177246,-0.9587705135345459,-0.8247494697570801,-1.124083995819092,-1.520723104476929,-1.647412776947021,-1.429617404937744,-1.111149787902832,-0.9521245956420898,-0.8407235145568848,-0.6895363330841064,-0.5933940410614014,-0.4963576793670654,-0.3331005573272705,-0.1523196697235107,-0.03579258918762207,-0.1806914806365967,-0.6906688213348389,-1.206666231155396,-1.439690589904785,-1.567214727401733,-1.907855272293091,-2.337902784347534,-2.218127250671387,-1.508146524429321,-0.8443892002105713,-0.6320178508758545,-0.6492137908935547,-0.5983412265777588,-0.6007254123687744,-0.7715225219726562,-1.003503799438477,-1.118481159210205,-0.9675323963165283,-0.6500780582427979,-0.4574358463287354,-0.463634729385376,-0.5741417407989502,-0.6627738475799561,-0.7370710372924805,-0.8164346218109131,-0.5131065845489502,0.1679360866546631,0.6854534149169922,0.7930994033813477,0.6672441959381104,0.4437565803527832,0.01740455627441406,-0.5858838558197021,-0.8828043937683105,-0.6280839443206787,0.02497434616088867,0.7032155990600586,1.062393188476562,1.112431287765503,1.213014125823975,1.462846994400024,1.480966806411743,1.261711120605469,1.173913478851318,1.37975811958313,1.833081245422363,2.343654632568359,2.534061670303345,2.300143241882324,1.795828342437744,1.168012619018555,0.5016326904296875,0.219494104385376,0.4960596561431885,0.9905099868774414,1.163095235824585,0.9773373603820801,1.004427671432495,1.318484544754028,1.58122181892395,1.799911260604858,1.952677965164185,1.734495162963867,1.216113567352295,0.8130967617034912,0.8943378925323486,1.433014869689941,1.803159713745117,1.549035310745239,0.8835792541503906,0.2733469009399414,0.08273124694824219,0.2300143241882324,0.4065036773681641,0.4546940326690674,0.2886950969696045,0.1724064350128174,0.29754638671875,0.3851354122161865,0.1621544361114502,-0.09638071060180664,-0.3903508186340332,-0.98380446434021,-1.525580883026123,-1.536548137664795,-0.9952783584594727,-0.2043247222900391,0.4651844501495361,0.8023083209991455,0.8361637592315674,0.7933974266052246,1.047730445861816,1.465022563934326,1.845121383666992,2.103149890899658,2.104908227920532,1.924902200698853,1.829534769058228,1.910567283630371,2.117544412612915,2.352923154830933,2.554416656494141,2.557247877120972,2.284139394760132,2.120226621627808,2.293139696121216,2.538561820983887,2.753764390945435,2.880305051803589,2.821356058120728,2.729624509811401,2.729237079620361,2.758651971817017,2.703070640563965,2.820432186126709,3.151178359985352,3.407388925552368,3.463089466094971,3.331005573272705,3.075569868087769,2.518147230148315,1.84941291809082,1.656979322433472,1.970916986465454,2.413421869277954,2.6131272315979,2.200692892074585,1.522094011306763,1.317352056503296,1.882553100585938,2.789884805679321,3.115981817245483,2.564609050750732,1.642227172851562,1.048922538757324,0.952303409576416,1.141756772994995,1.415669918060303,1.639842987060547,1.399576663970947,0.7982552051544189,0.5606412887573242,0.970304012298584,1.598358154296875,1.91226601600647,1.804769039154053,1.357465982437134,0.6787478923797607,0.1554787158966064,0.1929700374603271,0.7008612155914307,1.212626695632935,1.34044885635376,0.9913444519042969,0.6270706653594971,0.6596744060516357,0.886768102645874,0.9976327419281006,0.8597075939178467,0.6805360317230225,0.8012056350708008,1.042604446411133,1.099824905395508,0.9563267230987549,0.5886256694793701,0.0553429126739502,-0.3643333911895752,-0.5998909473419189,-0.5178451538085938,-0.117868185043335,0.110924243927002,-0.1520812511444092,-0.569075345993042,-0.6333887577056885,-0.4080832004547119,-0.05987286567687988,0.3369748592376709,0.4548430442810059,0.1192986965179443,-0.15509128570556]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>AR15</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>200</value></param>
<param><key>ymin</key><value>-200</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"direct audio"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
