<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xcorr_tester</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_mic_offset</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>ar15</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[-0.08978545665740967,-0.08273568004369736,-0.07058931142091751,-0.05722220614552498,-0.04422131925821304,-0.03723258152604103,-0.04354991391301155,-0.05887020379304886,-0.06817834824323654,-0.06231879815459251,-0.05078279972076416,-0.04953154176473618,-0.05780205875635147,-0.06714072078466415,-0.0711996853351593,-0.06506546586751938,-0.04013184085488319,-0.01770073547959328,-0.0237739197909832,-0.04348887503147125,-0.05844294652342796,-0.06595049798488617,-0.06924650073051453,-0.06289865076541901,-0.05969420447945595,-0.05990783497691154,-0.07284767925739288,-0.0955229327082634,-0.1041901931166649,-0.1122470796108246,-0.1160008534789085,-0.1113010048866272,-0.09390545636415482,-0.06756798177957535,-0.06042664870619774,-0.0636005774140358,-0.06274605542421341,-0.05743583664298058,-0.05475020781159401,-0.06076235324144363,-0.07260353118181229,-0.08322397619485855,-0.08127079159021378,-0.07522812485694885,-0.06790368258953094,-0.04681539535522461,-0.01760918088257313,0.01492355111986399,0.04617450386285782,0.06744590401649475,0.06167790666222572,0.04211554303765297,0.03674428537487984,0.0394604317843914,0.04705954343080521,0.0477614663541317,0.03778191655874252,0.03872798755764961,0.04589983820915222,0.05377361550927162,0.06308175623416901,0.0713217556476593,0.0872829407453537,0.1028778925538063,0.113193154335022,0.1122470796108246,0.1009552329778671,0.08795434236526489,0.0869472324848175,0.08200323581695557,0.0715659037232399,0.0634784996509552,0.06500442326068878,0.06744590401649475,0.05658131837844849,0.04257332161068916,0.03848383948206902,0.04666280001401901,0.06457716971635818,0.07882931083440781,0.08551286160945892,0.08014160394668579,0.06900235265493393,0.05624561384320259,0.05014191195368767,0.06088442727923393,0.06973479688167572,0.06888027489185333,0.07199316471815109,0.07986693829298019,0.0953703448176384,0.1181981861591339,0.1291238069534302,0.128604993224144,0.1233863309025764,0.1100802645087242,0.0871303454041481,0.06808679550886154,0.05935849994421005,0.06064027920365334,0.06234931573271751,0.05389568954706192,0.03808709979057312,0.02847377024590969,0.02606280706822872,0.02212592028081417,-0.007232886739075184,-0.04715109616518021,-0.06558427959680557,-0.07022309303283691,-0.06997894495725632,-0.07715079188346863,-0.09747611731290817,-0.1050141900777817,-0.1049226373434067,-0.1087679713964462,-0.1160008534789085,-0.1249732971191406,-0.1338541805744171,-0.1387371420860291,-0.1375164091587067,-0.126071959733963,-0.1062349304556847,-0.08127079159021378,-0.0876796767115593,-0.1118503361940384,-0.1278420388698578,-0.1323587745428085,-0.123630478978157,-0.1101412996649742,-0.1024201214313507,-0.09115878492593765,-0.07837153226137161,-0.07022309303283691,-0.06164738908410072,-0.06299020349979401,-0.05954161286354065,-0.0316782146692276,-0.00198370311409235,0.01654103212058544,0.01522873621433973,0.002563554793596268,0.004333628341555595,0.005920590832829475,-0.0005188146606087685,-0.006408886983990669,-0.004089480265974998,0.01776177249848843,0.04345835745334625,0.06695760786533356,0.08838160336017609,0.1031830832362175,0.1098666340112686,0.1047395244240761,0.09292886406183243,0.0869167149066925,0.09173864126205444,0.0950956791639328,0.079256571829319,0.06668294221162796,0.07321390509605408,0.09479048848152161,0.1199987828731537,0.1469771414995193,0.1629383265972137,0.1645558029413223,0.156224250793457,0.1494491398334503,0.1485030651092529,0.1632740199565887,0.1718192100524902,0.1673635095357895,0.1491439491510391,0.1189001128077507,0.1098971515893936,0.128330335021019,0.1385845541954041,0.1324198096990585,0.1094393730163574,0.08590960502624512,0.08154545724391937,0.08172857016324997,0.07196264714002609,0.0635395348072052,0.06225775927305222,0.05847346410155296,0.04113895073533058,0.01657155156135559,0.00991851557046175,0.01641895808279514,0.02710043638944626,0.02362132631242275,-0.002563554793596268,-0.0235297717154026,-0.02395703084766865,-0.01464888453483582,-0.01522873621433973,-0.03057954646646976,-0.0399792492389679,-0.0320139154791832,-0.02096621692180634,-0.01242103334516287,-0.004699850454926491,0.001678518019616604,0.002441480755805969,0.007690664380788803,0.0198065135627985,0.02938932552933693,0.02606280706822872,0.02462843805551529,0.027405621483922,0.02951139956712723,0.03704947233200073,0.04315317422151566,0.04928739368915558,0.05368205904960632,0.05236976221203804,0.05310220643877983,0.05352946743369102,0.06537064909934998,0.08426160365343094,0.08667256683111191,0.08093509078025818,0.07049775868654251,0.05880916863679886,0.03811761736869812,0.01553392130881548,0.0141911068931222,0.01361125521361828,0.003509628586471081,-0.0101016266271472,-0.02578814141452312,-0.039704579859972,-0.04443494975566864,-0.04208502545952797,-0.03125095367431641,-0.01904354989528656,-0.02227851189672947,-0.04422131925821304,-0.06997894495725632,-0.09070101380348206,-0.1027863398194313,-0.1017181947827339,-0.09393597394227982,-0.08447523415088654,-0.0713827908039093,-0.06039613112807274,-0.04968413338065147,-0.05493331700563431,-0.07684560865163803,-0.08243049681186676,-0.07065034657716751,-0.04962309822440147,-0.0392468050122261,-0.0559404268860817,-0.0718710869550705,-0.08102664351463318,-0.08432263880968094,-0.08603167533874512,-0.0868251621723175,-0.07797478884458542,-0.06860560923814774,-0.07007049769163132,-0.08658101409673691,-0.1065095961093903,-0.1026642695069313,-0.06918545812368393,-0.04986724629998207,-0.04849391058087349,-0.04589983820915222,-0.02887050993740559,-0.02108829095959663,-0.0237739197909832,-0.01904354989528656,-0.01016266364604235,-0.0007629627361893654,0.002899258397519588,-0.004913480021059513,-0.02209540084004402,-0.04300057888031006,-0.05493331700563431,-0.05911435186862946,-0.05801568552851677,-0.05160680040717125,-0.04397717118263245,-0.02993865869939327,-0.02096621692180634,-0.02288888208568096,-0.04260383918881416,-0.0555742047727108,-0.06183050200343132,-0.07284767925739288,-0.09305093437433243,-0.1140476688742638,-0.1204565539956093,-0.1100497469305992,-0.08926664292812347,-0.07205419987440109,-0.07367168366909027,-0.08954130858182907,-0.09793389588594437,-0.09976501017808914,-0.09985656291246414,-0.1010773032903671,-0.1176183372735977,-0.143467515707016,-0.1521347761154175,-0.145939514040947,-0.143681138753891,-0.1444441080093384,-0.1417889893054962,-0.1373027712106705,-0.1318704783916473,-0.1331217437982559,-0.143375962972641,-0.1499374359846115,-0.1491439491510391,-0.1416364014148712,-0.1332438141107559,-0.1280556619167328,-0.1200293004512787,-0.1135288551449776,-0.1022980436682701,-0.08377330750226974,-0.06613361090421677,-0.05844294652342796,-0.05279702320694923,-0.04199346899986267,-0.03415021300315857,-0.04651020839810371,-0.05951109528541565,-0.04934842884540558,-0.01144444104284048,0.01651051454246044,0.02215643785893917,0.02633747458457947,0.03762932121753693,0.05023346841335297,0.05328531935811043,0.04580828174948692,0.04263435676693916,0.03415021300315857,0.02172917872667313,0.002349925227463245,-0.02710043638944626,-0.05236976221203804,-0.0556657612323761,-0.04406872764229774,-0.03753776848316193,-0.04824976250529289,-0.06637775897979736,-0.06924650073051453,-0.06561479717493057,-0.05230872705578804,-0.04257332161068916,-0.0557573176920414,-0.08481093496084213,-0.1019013002514839,-0.09964293241500854,-0.08636738359928131,-0.07409894466400146,-0.07614368200302124,-0.08014160394668579,-0.06442457437515259,-0.02526932582259178,0.006164738908410072,0.005767998285591602,-0.01516769919544458,-0.006591998040676117,0.03118991665542126,0.0716879814863205,0.09070101380348206,0.09091463685035706,0.09955137968063354,0.1142918169498444,0.1216162592172623,0.1241493001580238,0.1337321102619171,0.1514328420162201,0.1643116623163223,0.1732230633497238,0.1781975775957108,0.1800592094659805,0.1803643852472305,0.1822260171175003,0.1774956583976746,0.1666005402803421,0.1749015748500824,0.1984618604183197,0.2163762301206589,0.2173223048448563,0.2113101631402969,0.2078005373477936,0.2015137225389481,0.1879024654626846,0.1673024743795395,0.1530503183603287,0.1499679535627365,0.1522568464279175,0.1542100310325623,0.1441083997488022,0.128635510802269,0.1207312270998955,0.1192663386464119,0.1149937435984612,0.1051362678408623,0.09475997090339661,0.08099612593650818,0.07208471745252609,0.06772056967020035,0.0557878352701664,0.03704947233200073,0.01718192175030708,-0.004486220888793468,-0.01467940304428339,-0.01132236700505018,0.0002746665850281715,0.01617481000721455,0.03018280677497387,0.02966399118304253,0.01748710684478283,-0.003418073058128357,-0.02584917843341827,-0.04254280403256416,-0.03869746997952461,-0.02917569503188133,-0.02188177220523357,-0.01702932827174664,-0.01239051483571529,-0.01086458936333656,-0.007904293946921825,-0.001892147585749626,0.003143406473100185,0.01391644030809402,0.0316782146692276,0.03375347331166267,0.027375103905797,0.02603228949010372,0.02697836235165596,0.01892147585749626,0.02758873254060745,0.04992828145623207,0.05221717059612274,0.04489272832870483,0.0397351011633873,0.0392773225903511,0.04336680099368095,0.04486221075057983,0.04214606061577797,0.03466902673244476,0.02780236303806305,0.03439436107873917,0.04913480207324028,0.05294961482286453,0.04330576583743095,0.01928769797086716,-0.006622516550123692,-0.02911465801298618,-0.04843287542462349,-0.05948057398200035,-0.06393627822399139,-0.06491287052631378,-0.06775109469890594,-0.06811731308698654,-0.06390576064586639,-0.06888027489185333,-0.08792382478713989,-0.09741508215665817,-0.08005005121231079,-0.0637226477265358,-0.06512650102376938,-0.07217627763748169,-0.0710776075720787,-0.06494338810443878,-0.05679494515061378,-0.05334635451436043,-0.06100650131702423,-0.07593005150556564,-0.08505508303642273,-0.06476027518510818,-0.04022339731454849,-0.04052858054637909,-0.05969420447945595,-0.08069094270467758,-0.08902249485254288,-0.08838160336017609,-0.07861568033695221,-0.06942960619926453,-0.06967375427484512,-0.08062990009784698,-0.09640797227621078,-0.09735404700040817,-0.08276619762182236,-0.07519760727882385,-0.0711691677570343,-0.07547227293252945,-0.09161656349897385,-0.08633686602115631,-0.07446516305208206,-0.06637775897979736,-0.05801568552851677,-0.05734428018331528,-0.06280709058046341,-0.07022309303283691,-0.06897183507680893,-0.06451612710952759,-0.06686605513095856,-0.07025361061096191,-0.06479079276323318,-0.05099643021821976,-0.03338725119829178,-0.01065095979720354,0.006408886983990669,0.0115359965711832,0.001434369944036007,-0.009552293457090855,-0.01123081147670746,0.001647999510169029,0.01950132846832275,0.03326517716050148,0.03540147095918655,0.04251228272914886,0.05404828116297722,0.05951109528541565,0.05819879844784737,0.0558488741517067,0.05923642590641975,0.05899227783083916,0.05279702320694923,0.05667287111282349,0.07211523503065109,0.06921598315238953,0.04583880305290222,0.01901303231716156,0.007263405248522758,0.01867732778191566,0.04629657790064812,0.06134220585227013,0.06540116667747498,0.06851405650377274,0.0714743509888649,0.05633717030286789,0.0398876927793026,0.0471816174685955,0.05847346410155296,0.06030457466840744,0.04977568984031677,0.03305154666304588,0.02371288277208805,0.02545243687927723,0.03476058319211006,0.04962309822440147,0.06030457466840744,0.06207465007901192,0.07193212956190109,0.08484145998954773,0.09671315550804138,0.1050752252340317,0.1041901931166649,0.09298989921808243,0.0791650116443634,0.07358012348413467,0.079256571829319,0.08893093466758728,0.1010162681341171,0.1046479716897011,0.09753715991973877,0.08630634844303131,0.07687612622976303,0.07562486827373505,0.08795434236526489,0.0951261967420578,0.08029419928789139,0.05313272401690483,0.0318308062851429,0.02526932582259178,0.03445539623498917,0.04425184056162834,0.04544205963611603,0.03524887934327126,0.01757866144180298,0.0008239997550845146,-0.005462813191115856,-0.009643848985433578,-0.01715140230953693,-0.01913510635495186,-0.0195623654872179,-0.0238044373691082,-0.03707998991012573,-0.06015198305249214,-0.08276619762182236,-0.09759819507598877,-0.09656056761741638,-0.09039582312107086,-0.09402752667665482,-0.1020538955926895,-0.1115451529622078,-0.1117893010377884,-0.107211522758007,-0.1068147867918015,-0.09439375251531601,-0.08474989980459213,-0.0954618975520134,-0.1127658933401108,-0.1253395229578018,-0.1214941889047623,-0.1152378916740417,-0.1130405589938164,-0.11444441229105,-0.1122775971889496,-0.1042817458510399,-0.1038850098848343,-0.1039460450410843,-0.09918515384197235,-0.08401745557785034,-0.05499435588717461,-0.03897213563323021,-0.0399182103574276,-0.04806665331125259,-0.04910428076982498,-0.04287850484251976,-0.0399487279355526,-0.0397961363196373,-0.03537095338106155,-0.03234962001442909,-0.02362132631242275,0.004272591322660446,0.0313730277121067,0.05108798667788506,0.0709250196814537,0.08105716109275818,0.07309182733297348,0.05752738937735558,0.04544205963611603,0.04422131925821304,0.04931791126728058,0.04998932033777237,0.04947050288319588,0.05200354009866714,0.06076235324144363,0.07284767925739288,0.08368175476789474,0.0872829407453537,0.08450575172901154,0.09628589451313019,0.1187169998884201,0.1374858915805817,0.145817443728447,0.1479842513799667,0.1427045464515686,0.1340983361005783,0.1217688545584679,0.1104464828968048,0.1065401136875153,0.1040070801973343,0.1059602648019791,0.09421063959598541,0.0711691677570343,0.04870754107832909,0.031434066593647,0.02154606766998768,0.02169866114854813,0.02639851160347462,0.0313425101339817,0.02874843589961529,0.02117984555661678,0.02154606766998768,0.01284829247742891,-0.005737479776144028,-0.01016266364604235,-0.001037629321217537,0.001739555038511753,0.002410962246358395,0.009826960042119026,0.02108829095959663,0.0278939176350832,0.03122043609619141,0.03265480697154999,0.02871791832149029,0.03012176975607872,0.0279854740947485,0.01602221839129925,0.005859553813934326,0.00039674062281847,0.0007019257172942162,0.002594073303043842,0.004638813436031342,0.01052888575941324,0.02258369699120522,0.02993865869939327,0.03759880363941193,0.03881954401731491,0.02880947291851044,0.006866664625704288,-0.01516769919544458,-0.01034577470272779,0.007904293946921825,0.01760918088257313,0.01046784874051809,-0.006561479531228542,-0.02279732748866081,-0.03582873195409775,-0.04428235813975334,-0.0398876927793026,-0.02533036284148693,-0.01535081025213003,-0.01446577347815037,-0.007965330965816975,0.002471999265253544,0.01416058838367462,0.0281075481325388,0.03009125031530857,0.01763969846069813,0.01614429242908955,0.02731406688690186,0.03701895102858543,0.0399487279355526,0.05496383458375931,0.08172857016324997,0.09210485965013504,0.09759819507598877,0.1038239672780037,0.1154515221714973,0.1352580338716507,0.1495712101459503,0.1597643941640854,0.1641895771026611,0.1614429205656052,0.1672719568014145,0.1823480874300003,0.1920224577188492,0.1949217170476913,0.189001128077507,0.1841181665658951,0.1850337237119675,0.1932737231254578,0.2106082290410995,0.2326731234788895,0.2406994849443436,0.2243720889091492,0.1850337237119675,0.1578112095594406,0.1452681124210358,0.1337321102619171,0.1251258850097656,0.1474349200725555,0.1771904677152634,0.1658375859260559,0.1300698816776276,0.09897152334451675,0.08822900801897049,0.08993804454803467,0.07809686660766602,0.0558183528482914,0.03524887934327126,0.01760918088257313,-0.01895199529826641,-0.06634724140167236,-0.1046784892678261,-0.1300698816776276,-0.1349833607673645,-0.1428571492433548,-0.171544536948204,-0.2068239450454712,-0.2219306081533432,-0.2159794867038727,-0.2072817236185074,-0.2086245268583298,-0.2375255525112152,-0.2670369446277618,-0.28235724568367,-0.2864162027835846,-0.2881862819194794,-0.3051851093769073,-0.3249000608921051,-0.3387554585933685,-0.347331166267395,-0.3440351486206055,-0.3326212465763092,-0.3111667335033417,-0.2990203499794006,-0.3030182719230652,-0.3082979917526245,-0.3069856762886047,-0.3037507236003876,-0.2992644906044006,-0.287575900554657,-0.2526017129421234,-0.2092349082231522,-0.1838435083627701,-0.1707510650157928,-0.156224250793457,-0.143772691488266,-0.1279030740261078,-0.1138645559549332,-0.1050752252340317,-0.08923612534999847,-0.07483138889074326,-0.06173894554376602,-0.0472121350467205,-0.03756828606128693,-0.04077272862195969,-0.06146427989006042,-0.07721182703971863,-0.0791344940662384,-0.07223731279373169,-0.05969420447945595,-0.04144413769245148,-0.02703939937055111,-0.006378368474543095,0.01159703359007835,-0.005706961266696453,-0.0473952442407608,-0.09063997119665146,-0.09915463626384735,-0.08432263880968094,-0.079256571829319,-0.08502456545829773,-0.09793389588594437,-0.09851375222206116,-0.09454634040594101,-0.09018219262361526,-0.08041626960039139,-0.08960234373807907,-0.09979552775621414,-0.08816797286272049,-0.07852412760257721,-0.07782220095396042,-0.09201330691576004,-0.1036103367805481,-0.1022675260901451,-0.09631641954183578,-0.0868251621723175,-0.08807642012834549,-0.09585864096879959,-0.09277626872062683,-0.0790734589099884,-0.06079287081956863,-0.03692739829421043,-0.005890072323381901,0.02044740132987499,0.03097628802061081,0.02191228978335857,0.01721243932843208,0.01879940181970596,0.02255317941308022,0.03601184114813805,0.05941953882575035,0.0711691677570343,0.07193212956190109,0.0717795342206955,0.06689657270908356,0.06692709028720856,0.09164708107709885,0.1172521114349365,0.1166722625494003,0.09585864096879959,0.07208471745252609,0.07397686690092087,0.107058934867382,0.1156041175127029,0.1073030829429626,0.09781182557344437,0.09659108519554138,0.1046784892678261,0.1074861884117126,0.1098666340112686,0.1191442608833313,0.1347392201423645,0.1495712101459503,0.1472212970256805,0.1322061866521835,0.1081881150603294,0.08795434236526489,0.08120975643396378,0.1056855991482735,0.1456648409366608,0.1532639563083649,0.1382793635129929,0.1176793724298477,0.09854426980018616,0.08359019458293915,0.06707968562841415,0.0556962788105011,0.03787346929311752,0.008484145626425743,-0.01760918088257313,-0.0161137729883194,-0.01034577470272779,-0.01553392130881548,-0.01800592057406902,-0.0274971779435873,-0.04327524825930595,-0.04113895073533058,-0.0319223627448082,-0.0476699136197567,-0.09012115746736526,-0.13068026304245,-0.1415753662586212,-0.1356242597103119,-0.1373332887887955,-0.158909872174263,-0.186437577009201,-0.1961424648761749,-0.1807306110858917,-0.1636097282171249,-0.1530808508396149,-0.1481673568487167,-0.143772691488266,-0.1313821822404861,-0.126102477312088,-0.1330607086420059,-0.1339762508869171,-0.1356852948665619,-0.1554002463817596,-0.1730094254016876,-0.1652882546186447,-0.145878478884697,-0.1231421828269958,-0.1118808537721634,-0.1407818794250488,-0.1667836606502533,-0.1569261699914932,-0.1331827789545059,-0.1066316738724709,-0.09082308411598206,-0.0877407118678093,-0.08072146028280258,-0.05734428018331528,-0.02713095583021641,-0.00714133121073246,0.00079348124563694,-0.002166814170777798,-0.02014221623539925,-0.03515732288360596,-0.03512680530548096,-0.02465895563364029,-0.003265480510890484,0.01754814386367798,0.02551347389817238,0.02545243687927723,0.02917569503188133,0.03900265693664551,0.04550309851765633,0.03561510145664215,0.02444532699882984,0.02658162266016006,0.03466902673244476,0.03445539623498917,0.01989806815981865,0.008880886249244213,0.005767998285591602,0.007629627361893654,0.01846369914710522,0.03781243413686752,0.05026398599147797,0.0556047260761261,0.06570634990930557,0.07879879325628281,0.08789330720901489,0.09628589451313019,0.107058934867382,0.1301003992557526,0.1580553650856018,0.1831720918416977,0.1892452836036682,0.1963560879230499,0.2162541598081589,0.2291634827852249,0.2253181487321854,0.2226325273513794,0.2349620014429092,0.234199047088623,0.2247993350028992,0.2289803773164749,0.2312997877597809,0.2203131169080734,0.2001403868198395,0.176152840256691,0.1602221727371216,0.156254768371582,0.1570177376270294,0.1531418859958649,0.1524399518966675,0.1471297293901443,0.1421857327222824,0.1393169909715652,0.1344950646162033,0.1286965608596802,0.1118198186159134,0.09421063959598541,0.07190161198377609,0.0555436871945858,0.06009094417095184,0.06402783095836639,0.05267494916915894,0.0281075481325388,0.00991851557046175,0.008270516060292721,0.02618488110601902,0.04876857995986938,0.04892117157578468,0.03607288002967834,0.02410962246358395,0.01907406933605671,0.03222754597663879,0.05984679609537125,0.07498397678136826,0.08377330750226974,0.08801538497209549,0.079226054251194,0.0711081251502037,0.07980590313673019,0.0949430838227272,0.1116061881184578,0.1269569993019104,0.143406480550766,0.1625415831804276,0.1606799513101578,0.1443830728530884,0.1297341883182526,0.1315958201885223,0.1616870611906052,0.1794488430023193,0.160893589258194,0.1318704783916473,0.113315224647522,0.113315224647522,0.1228369995951653,0.1179540380835533,0.1003143414855003,0.07684560865163803,0.05728324130177498,0.06179998070001602,0.07324442267417908,0.0716879814863205,0.07263405621051788,0.08221686631441116,0.08066041767597198,0.04989776387810707,0.04446546733379364,0.07061982899904251,0.09244056791067123,0.09781182557344437,0.0951872318983078,0.09137241542339325,0.08569597452878952,0.08505508303642273,0.08627582341432571,0.07770012319087982,0.06149479746818542,0.04202398657798767,0.02865688130259514,0.02420117892324924,0.03619495406746864,0.05462813377380371,0.05212561413645744,0.02279732748866081,0.001770073547959328,-0.01556443981826305,-0.0316171757876873,-0.047883540391922,-0.06912442296743393,-0.09790337830781937,-0.1123081147670746,-0.1093173027038574,-0.1103854477405548,-0.1292764097452164,-0.1676686853170395,-0.1883602440357208,-0.1946775764226913,-0.2016663104295731,-0.2268135696649551,-0.2689290940761566,-0.286935031414032,-0.2754295468330383,-0.2509842216968536,-0.2310556322336197,-0.2350840717554092,-0.2641987502574921,-0.2854090929031372,-0.2915433347225189,-0.2839137017726898,-0.2732322216033936,-0.256508082151413,-0.2306588888168335,-0.2049928307533264,-0.1810968369245529,-0.1542405486106873,-0.1208532974123955,-0.1048921197652817,-0.1039155274629593,-0.08377330750226974,-0.0475173182785511,-0.01770073547959328,0.005676442757248878,0.01257362589240074,0.01977599412202835,0.03555406257510185,0.05047761648893356,0.06933805346488953,0.08664204925298691,0.07629627734422684,0.04828028380870819,0.03405865654349327,0.04614398628473282,0.07827997952699661,0.0791039764881134,0.0475173182785511,0.0162358470261097,-0.0001220740377902985,0.004669331945478916,0.02996917627751827,0.05203405767679214,0.04925687611103058,0.03424176946282387,0.007415997795760632,-0.02493362314999104,-0.05508590862154961,-0.06060976162552834,-0.04876857995986938,-0.04553361609578133,-0.05420087277889252,-0.05722220614552498,-0.04275643080472946,-0.02423169650137424,-0.01312295906245708,-0.008575701154768467,-0.006836146116256714,-0.0140690328553319,-0.02157658711075783,-0.02664265967905521,-0.03299050778150558,-0.03344828635454178,-0.03103732503950596,-0.02319406718015671,-0.007721182890236378,0.006591998040676117,0.02487258613109589,0.03457747027277946,0.0159611813724041,-0.009887997061014175,-0.01373332925140858,-0.009063997305929661,-0.0079348124563694,-0.005493331700563431,-0.008575701154768467,-0.01657155156135559,-0.01281777396798134,-0.01040681172162294,-0.02194280922412872,-0.04947050288319588,-0.09439375251531601,-0.1106906309723854,-0.09643848985433578,-0.0872218981385231,-0.08505508303642273,-0.08258308470249176,-0.09298989921808243,-0.1087984889745712,-0.1102328598499298,-0.09680471569299698,-0.07358012348413467,-0.04565569013357162,-0.02429273352026939,-0.0102237006649375,-0.001770073547959328,-0.00238044373691082,-0.02639851160347462,-0.05282754078507423,-0.04669332131743431,-0.01425214391201735,0.027375103905797,0.05856502056121826,0.06445509195327759,0.05389568954706192,0.05066072568297386,0.06265450268983841,0.08478041738271713,0.1091036722064018,0.1091341897845268,0.07217627763748169,0.04531998559832573,0.04263435676693916,0.05429242923855782,0.06769005209207535,0.06537064909934998,0.0634174644947052,0.07214576005935669,0.08374278992414474,0.09192175418138504,0.1004669368267059,0.1199377402663231,0.1371501833200455,0.1269875168800354,0.09408856183290482,0.06399731338024139,0.05755791068077087,0.07428205013275146,0.07770012319087982,0.06472975760698318,0.05612353980541229,0.0637836828827858,0.08273568004369736,0.0954924151301384,0.09076204895973206,0.08059938251972198,0.08182012289762497,0.09094516187906265,0.1068758219480515,0.1211584806442261,0.1313821822404861,0.1242103353142738,0.1115146353840828,0.1123386323451996,0.113254189491272,0.1087679713964462,0.08871730417013168,0.07565538585186005,0.07760857045650482,0.06903287023305893,0.05240027979016304,0.03439436107873917,0.009796441532671452,-0.02117984555661678,-0.05502487346529961,-0.07351908832788467,-0.07071138918399811,-0.05838190764188766,-0.06384472548961639,-0.09262367337942123,-0.1341898888349533,-0.1703238040208817,-0.1828669160604477,-0.1834772825241089,-0.1905270516872406,-0.208990752696991,-0.2273018658161163,-0.2379222959280014,-0.2410962283611298,-0.2399059981107712,-0.2495193332433701,-0.2677999138832092,-0.2630390226840973,-0.2419812679290771,-0.2194891273975372,-0.1989806890487671,-0.186437577009201,-0.1868648380041122,-0.1956541687250137,-0.2036805301904678,-0.2105471938848495,-0.2102725356817245,-0.2060609757900238,-0.2074037939310074,-0.2002624571323395,-0.2012695670127869,-0.2085329741239548,-0.2084414213895798,-0.1998046785593033,-0.1721549183130264,-0.1470381766557693,-0.1290932893753052,-0.1325418800115585,-0.158482626080513,-0.1810052841901779,-0.1789300143718719,-0.161046177148819,-0.1542100310325623,-0.1591540277004242,-0.1729483902454376,-0.1787469089031219,-0.1659596562385559,-0.1450849920511246,-0.1307412981987,-0.1323282569646835,-0.1450849920511246,-0.1520737260580063,-0.1510971337556839,-0.143436998128891,-0.1362041085958481,-0.1544236540794373,-0.1807611286640167,-0.1749320924282074,-0.1529587656259537,-0.1420636624097824,-0.1546067744493484,-0.1485641002655029,-0.109714038670063,-0.09051790088415146,-0.08459731191396713,-0.08127079159021378,-0.07394634932279587,-0.06689657270908356,-0.0710776075720787,-0.07046724110841751,-0.0632343515753746,-0.05191198363900185,-0.0314035452902317,0.0007324442267417908,0.009765923023223877,0.0001525925472378731,-0.006927701644599438,-0.004089480265974998,0.03305154666304588,0.08148442208766937,0.1147190779447556,0.1463057398796082,0.1698660254478455,0.1882686913013458,0.1968443840742111,0.2028565257787704,0.2195806801319122,0.2493362277746201,0.2863246500492096,0.3066805005073547,0.2946867346763611,0.2861720621585846,0.2928251028060913,0.3061922192573547,0.3157139718532562,0.3256935477256775,0.3223059773445129,0.3118076026439667,0.299722284078598,0.286843478679657,0.2729575634002686,0.241889700293541,0.2073732763528824,0.1951048374176025,0.1971495747566223,0.1909848302602768,0.1644337326288223,0.14090396463871,0.1402935832738876,0.1572008430957794,0.1758171319961548,0.1837519407272339,0.1632435023784637,0.1167638152837753,0.08877834677696228,0.08041626960039139,0.09564501047134399,0.1184118166565895,0.1266823261976242,0.0954924151301384,0.04934842884540558,0.02188177220523357,0.03604235872626305,0.06985686719417572,0.08334604650735855,0.08236945420503616,0.09048738330602646,0.1080660447478294,0.1327555179595947,0.1531418859958649,0.1605883985757828,0.161229282617569,0.1690725386142731,0.1877193450927734,0.2164067476987839,0.2647480666637421,0.2943204939365387,0.304208517074585,0.299356073141098,0.2662740051746368,0.2178106009960175,0.2106082290410995,0.2361827492713928,0.257057398557663,0.2550126612186432,0.224280521273613,0.1843318045139313,0.1695608347654343,0.1673635095357895,0.1598254293203354,0.1689504683017731,0.186529129743576,0.1799066066741943,0.1470992118120193,0.1118198186159134,0.07205419987440109,0.05154576152563095,0.04074221104383469,0.01196325570344925,-0.01101718191057444,-0.01489303261041641,-0.00674459058791399,-0.0009765923023223877,-0.01895199529826641,-0.04016235843300819,-0.05676442757248878,-0.06997894495725632,-0.0790734589099884,-0.0795922726392746,-0.08233893662691116,-0.09289834648370743,-0.1164586320519447,-0.1470076590776443,-0.1640980243682861,-0.141056552529335,-0.079409159719944,-0.02838221378624439,-0.0004272591322660446,-0.00872829370200634,-0.04031495004892349,-0.08191168308258057,-0.09732352942228317,-0.07358012348413467,-0.03585924953222275,0.003814813680946827,0.0234382152557373,0.02661214023828506,0.03604235872626305,0.04589983820915222,0.04818872734904289,0.04919583722949028,0.07522812485694885,0.1002838239073753,0.09671315550804138,0.08233893662691116,0.06826990842819214,0.05407879874110222,0.02237006835639477,0.01083407085388899,0.01861629076302052,0.03021332435309887,0.06247138977050781,0.08490249514579773,0.0556962788105011,0.01156651508063078,-0.02587969601154327,-0.04461806267499924,-0.06140324100852013,-0.0953093022108078,-0.1264076679944992,-0.1355937421321869,-0.1275673657655716,-0.1059907823801041,-0.09201330691576004,-0.1000701934099197,-0.1268959641456604,-0.156224250793457,-0.1720633506774902,-0.1770378798246384,-0.1814325451850891,-0.2000183165073395,-0.2164983004331589,-0.2081057131290436,-0.1861018687486649,-0.1723380237817764,-0.1815240979194641,-0.1893673539161682,-0.1990112066268921,-0.2008423060178757,-0.1956541687250137,-0.189153715968132,-0.1871089786291122,-0.1909237951040268,-0.1742301732301712,-0.1576891392469406,-0.1502121090888977,-0.1372722536325455,-0.1188390776515007,-0.09863582253456116,-0.08087404817342758,-0.06750694662332535,-0.06213568523526192,-0.06253242492675781,-0.05444502085447311,-0.04257332161068916,-0.03128147125244141,-0.01452681049704552,-0.005340739153325558,0.01217688526958227,0.04525895044207573,0.0713827908039093,0.08554337918758392,0.0795922726392746,0.05478072538971901,0.04254280403256416,0.06210516765713692,0.0954008623957634,0.1154820397496223,0.1073336005210876,0.06430249661207199,0.04675435647368431,0.06942960619926453,0.1053498983383179,0.1322061866521835,0.1276589184999466,0.1026642695069313,0.08334604650735855,0.07895138114690781,0.08993804454803467,0.1241187751293182,0.1662648469209671,0.1628162413835526,0.1340678185224533,0.1098361164331436,0.1020538955926895,0.09649952501058578,0.1035493016242981,0.1319009959697723,0.1614124029874802,0.1745353490114212,0.1749931275844574,0.1849726885557175,0.1803338676691055,0.1566209942102432,0.1249122619628906,0.1045869290828705,0.1061738952994347,0.1271706223487854,0.12472914904356,0.08520767837762833,0.04083376750349998,0.01452681049704552,0.01413006987422705,-0.001953184604644775,-0.0276497695595026,-0.0313119925558567,-0.02929776906967163,-0.0320444367825985,-0.05435346439480782,-0.09207434207201004,-0.1203650012612343,-0.1302530020475388,-0.143650621175766,-0.1653187721967697,-0.1823175698518753,-0.171483501791954,-0.1800286918878555,-0.2222663015127182,-0.2881557643413544,-0.3214209377765656,-0.2807092368602753,-0.2110965251922607,-0.1802423149347305,-0.2017273455858231,-0.2614215612411499,-0.3270058333873749,-0.3628345727920532,-0.3663747012615204,-0.364909827709198,-0.3718070089817047,-0.3836176693439484,-0.395306259393692,-0.3788872957229614,-0.3396404981613159,-0.3094576895236969,-0.2981963455677032,-0.2953581213951111,-0.2687154710292816,-0.2258064448833466,-0.2004455775022507,-0.193945124745369,-0.1959288269281387,-0.1920834928750992,-0.1721244007349014,-0.1493270695209503,-0.1419110745191574,-0.1526841074228287,-0.1666310578584671,-0.1823480874300003,-0.1722464710474014,-0.1405072212219238,-0.09900204837322235,-0.06970427930355072,-0.08822900801897049,-0.123508408665657,-0.114474929869175,-0.07516708970069885,-0.05172887444496155,-0.05874812975525856,-0.07214576005935669,-0.06186101958155632,-0.04220709949731827,-0.03863643482327461,-0.0395825058221817,-0.031464584171772,-0.01199377421289682,-0.002044740132987499,0.02099673449993134,0.04257332161068916,0.02905362099409103,-0.02072206884622574,-0.05728324130177498,-0.0709250196814537,-0.08026368170976639,-0.08017212152481079,-0.05850398167967796,-0.03115939907729626,-0.03277688100934029,-0.03637806326150894,-0.04596087709069252,-0.06698812544345856,-0.07776116579771042,-0.06741538643836975,-0.04614398628473282,-0.02438428997993469,-0.007782219909131527,0.02511673420667648,0.06552323698997498,0.07431256771087646,0.05505539104342461,0.0472121350467205,0.05835139006376266,0.07196264714002609,0.1104770079255104,0.1481063216924667,0.17368084192276,0.1892147660255432,0.1972716450691223,0.1928769797086716,0.1895504593849182,0.2454603761434555,0.3211157619953156,0.3814813792705536,0.4062929153442383,0.4028443396091461,0.382335901260376,0.3449201881885529,0.3066194653511047,0.2878505885601044,0.2848292589187622,0.2712485194206238,0.2721030414104462,0.3056733906269073,0.3428144156932831,0.3582262694835663,0.3404034674167633,0.3229468762874603,0.3417157530784607,0.3786126375198364,0.3868831396102905,0.3508712947368622,0.3023774027824402,0.2839442193508148,0.2909634709358215,0.3142796158790588,0.3388775289058685,0.3362224102020264,0.2949919104576111,0.2443006634712219,0.224036380648613,0.2297433465719223,0.2257454097270966,0.186376541852951,0.1097750812768936,0.05856502056121826,0.04229865595698357,0.03390606492757797,0.02554399333894253,0.02645954862236977,0.0394909530878067,0.03433332219719887,0.01327555160969496,0.006897183135151863,0.01867732778191566,0.02325510419905186,-0.01425214391201735,-0.05163731798529625,-0.07068087160587311,-0.06390576064586639,-0.04159672930836678,-0.0399182103574276,-0.06918545812368393,-0.08633686602115631,-0.1115451529622078,-0.1424298882484436,-0.1600085496902466,-0.1642200946807861,-0.1775566935539246,-0.1791131347417831,-0.1622974276542664,-0.1662953644990921,-0.2072817236185074,-0.2483291178941727,-0.2584612667560577,-0.2468642294406891,-0.2185125350952148,-0.1769157946109772,-0.1160313710570335,-0.05880916863679886,-0.0473342090845108,-0.0632648691534996,-0.09161656349897385,-0.1242408528923988,-0.1509750634431839,-0.156346321105957,-0.1287881135940552,-0.0869472324848175,-0.07879879325628281,-0.1198767051100731,-0.1539353579282761,-0.1510360985994339,-0.1332132965326309,-0.1065401136875153,-0.06140324100852013,-0.009613330475986004,-0.002075258642435074,-0.03112887963652611,-0.06268502026796341,-0.05377361550927162,-0.01785332895815372,-0.02487258613109589,-0.06640827655792236,-0.107119970023632,-0.1419415920972824,-0.1665700227022171,-0.1380047053098679,-0.07647938281297684,-0.04638813436031342,-0.0631427988409996,-0.09994811564683914,-0.1159093007445335,-0.1019318252801895,-0.07385479658842087,-0.04992828145623207,-0.04065065458416939,-0.03854487836360931,-0.05133213475346565,-0.07348857074975967,-0.08523819595575333,-0.07394634932279587,-0.039674062281847,-0.004394665360450745,-0.0009460737928748131,-0.005096591077744961,0.007965330965816975,0.03506576642394066,0.05710013210773468,0.05645924434065819,0.04565569013357162,0.0317392498254776,0.02194280922412872,0.03329569473862648,0.06137272343039513,0.08960234373807907,0.08255256712436676,0.08081301301717758,0.08465834707021713,0.08120975643396378,0.06091494485735893,0.03674428537487984,0.03350932523608208,0.02661214023828506,0.01709036529064178,-0.007171849720180035,-0.03277688100934029,-0.03469954431056976,-0.03753776848316193,-0.05108798667788506,-0.06088442727923393,-0.06396679580211639,-0.0631427988409996,-0.08117923885583878,-0.09979552775621414,-0.1028168573975563,-0.08517716079950333,-0.06137272343039513,-0.03866695240139961,-0.004272591322660446,0.03057954646646976,0.03085421398282051,-0.01120029296725988,-0.06027405709028244,-0.04443494975566864,-0.01223792228847742,0.02322458662092686,0.0710165724158287,0.1001312285661697,0.09747611731290817,0.08462782949209213,0.1009552329778671,0.1314126998186111,0.1448408514261246,0.1386761069297791,0.1386761069297791,0.1657460182905197,0.2100588977336884,0.2529374063014984,0.2846461236476898,0.2586748898029327,0.2004150450229645,0.1921750605106354,0.2101809680461884,0.221655935049057,0.2106387466192245,0.17380291223526,0.1406598091125488,0.1388897299766541,0.1471602469682693,0.1395916640758514,0.1146885603666306,0.09042634069919586,0.07879879325628281,0.05258339270949364,0.003143406473100185,-0.03787346929311752,-0.02548295632004738,0.00872829370200634,0.03283791616559029,0.06735435128211975,0.08243049681186676,0.06900235265493393,0.04660176485776901,0.04943998530507088,0.09286782145500183,0.1377605497837067,0.1575670689344406,0.1391644030809402,0.1188390776515007,0.1279946267604828,0.1448713690042496,0.1472212970256805,0.1491134315729141,0.1766411364078522,0.2195806801319122,0.2337412685155869,0.2247077822685242,0.1945554912090302,0.1591540277004242,0.1281166970729828,0.1134067848324776,0.1225623339414597,0.1295815855264664,0.1402325481176376,0.1371196657419205,0.09637745469808578,0.05352946743369102,0.005310220643877983,-0.05825983360409737,-0.1388592123985291,-0.1845149099826813,-0.1709341704845428,-0.143559068441391,-0.1328470706939697,-0.1545152068138123,-0.1825312077999115,-0.2226935625076294,-0.2628864347934723,-0.2850123643875122,-0.299783319234848,-0.3205969333648682,-0.3488265573978424,-0.3610339760780334,-0.3588366210460663,-0.3593249320983887,-0.34778892993927,-0.3229163587093353,-0.2766807973384857,-0.2109439373016357,-0.1722464710474014,-0.1495101749897003,-0.1363872140645981,-0.1361125558614731,-0.1546067744493484,-0.173711359500885,-0.1718802452087402,-0.1474654376506805,-0.1074251532554626,-0.05917539075016975,-0.04297006130218506,-0.03674428537487984,-0.04705954343080521,-0.0556047260761261,-0.02694784477353096,0.06195257604122162,0.123599961400032,0.1051362678408623,0.05722220614552498,0.001464888453483582,-0.03878902643918991,-0.07074190676212311,-0.09384441375732422,-0.08478041738271713,-0.04150517284870148,0.001525925472378731,0.01461836602538824,0.009216589853167534,0.03042695485055447,0.07016205042600632,0.1033051535487175,0.128238782286644,0.1598864644765854,0.2098147571086884,0.2446363717317581,0.2527543008327484,0.2498245239257812,0.2582476139068604,0.2580034732818604,0.269783616065979,0.2980437576770782,0.347453236579895,0.4020508527755737,0.4445326030254364,0.4624469876289368,0.4802392721176147,0.5062105059623718,0.5479903817176819,0.5778679847717285,0.5658131837844849,0.5428327322006226,0.5520798563957214,0.5612658858299255,0.5700857639312744,0.5914792418479919,0.6222113966941833,0.6286202669143677,0.6007568836212158,0.5313882827758789,0.4468520283699036,0.3718680441379547,0.3238319158554077,0.2792748808860779,0.2294076383113861,0.161137729883194,0.08352915942668915,-0.006103701889514923,-0.07235938310623169,-0.1225012987852097,-0.1784112006425858,-0.2401806712150574,-0.3066805005073547,-0.34730064868927,-0.3708914518356323,-0.3878292143344879,-0.4206671416759491,-0.5027619004249573,-0.5975219011306763,-0.6236762404441833,-0.6183965802192688,-0.6109805703163147,-0.6128116846084595,-0.6217840909957886,-0.6285592317581177,-0.6049379110336304,-0.5647755265235901,-0.5233314037322998,-0.4895168840885162,-0.4658345282077789,-0.4345225393772125,-0.4083071351051331,-0.3887142539024353,-0.3499252200126648,-0.2932218313217163,-0.2289498597383499,-0.191320538520813,-0.1892452836036682,-0.1992553472518921,-0.2037415653467178,-0.1753898710012436,-0.1067842617630959,-0.04916531965136528,-0.02233954891562462,-0.01141392253339291,-0.01898251287639141,-0.0138248847797513,0.01867732778191566,0.05352946743369102,0.05468916893005371,0.02468947507441044,-0.002349925227463245,0.02160710468888283,0.07367168366909027,0.08304086327552795,0.08569597452878952,0.0710165724158287,0.03573717549443245,0.02652058564126492,0.0557878352701664,0.09756767749786377,0.112094484269619,0.09799493104219437,0.06888027489185333,0.04156621173024178,0.005890072323381901,-0.0002746665850281715,0.02560503035783768,0.05905331671237946,0.1001007109880447,0.1196630746126175,0.1131321117281914,0.09692678600549698,0.09955137968063354,0.1178930029273033,0.1318704783916473,0.1496017277240753,0.1447187662124634,0.1414838135242462,0.1419721096754074,0.1139866337180138,0.06237983331084251,0.02514725178480148,0.03012176975607872,0.03460799157619476,0.006317331455647945,-0.01532029174268246,-0.03506576642394066,-0.04382457956671715,-0.04812768846750259,-0.0556657612323761,-0.0794702023267746,-0.1279641091823578,-0.128635510802269,-0.09295938163995743,-0.06289865076541901,-0.03305154666304588,-0.03244117647409439,-0.04803613573312759,-0.05093539133667946,-0.02597125247120857,-0.007385479286313057,-0.0280159916728735,-0.06088442727923393,-0.07208471745252609,-0.03543198853731155,0.007171849720180035,0.02487258613109589,-0.004425183869898319,-0.05462813377380371,-0.06527908891439438,-0.0634174644947052,-0.04962309822440147,-0.03305154666304588,-0.0276497695595026,-0.07712027430534363,-0.161015659570694,-0.2362437844276428,-0.2890713214874268,-0.2925199270248413,-0.234351634979248,-0.188970610499382,-0.1984618604183197,-0.2300180047750473,-0.2586443722248077,-0.2587664425373077,-0.2607501447200775,-0.2716452479362488,-0.2666096985340118,-0.2715842127799988,-0.2804956138134003,-0.3144627213478088,-0.3803216516971588,-0.4444105327129364,-0.4897610545158386,-0.4767906665802002,-0.3846247792243958,-0.2409741580486298,-0.161198765039444,-0.1308633685112,-0.09320352971553802,-0.08578752726316452,-0.1597033590078354,-0.2223273366689682,-0.2245246767997742,-0.191228985786438,-0.1233863309025764,-0.03903317451477051,0.03393658250570297,0.0710165724158287,0.07248146086931229,0.0795922726392746,0.1122775971889496,0.1293374449014664,0.1495101749897003,0.2119510471820831,0.2768333852291107,0.3060090839862823,0.2665181457996368,0.2147587537765503,0.2251350432634354,0.2428357750177383,0.2295907437801361,0.2197943031787872,0.2006897181272507,0.1497543305158615,0.08438368141651154,0.02197332680225372,0.01077303383499384,0.03814813867211342,0.08008056879043579,0.1052583381533623,0.09640797227621078,0.06952116638422012,0.05316324532032013,0.04068117216229439,0.02911465801298618,0.05761894583702087,0.07483138889074326,0.03271584212779999,-0.05288857594132423,-0.1420331448316574,-0.145939514040947,-0.0872524157166481,-0.0552079826593399,-0.06161687150597572,-0.1331217437982559,-0.1977294236421585,-0.2175969779491425,-0.2005371302366257,-0.1784722506999969,-0.1251258850097656,-0.05398724228143692,-0.09778130799531937,-0.2264168262481689,-0.3160496950149536,-0.3407696783542633,-0.2930997610092163,-0.2212591916322708,-0.1741691380739212,-0.1783501654863358,-0.1988891214132309,-0.2014526873826981,-0.1812799423933029,-0.1934873461723328,-0.2339243739843369,-0.2106387466192245,-0.1440168470144272,-0.0791955292224884,-0.04513687640428543,-0.06216620281338692,-0.08453626930713654,-0.1024811565876007,-0.1045564115047455,-0.08203375339508057,-0.09045686572790146,-0.1079744845628738,-0.1008026376366615,-0.0953703448176384,-0.06131168454885483,-0.01434369944036007,-0.03054902888834476,-0.1496017277240753,-0.2552873194217682,-0.2733848094940186,-0.203985720872879,-0.06628620624542236,0.08365123718976974,0.04467909783124924,-0.1098055988550186,-0.1618701815605164,-0.0632038339972496,0.07760857045650482,0.1727042496204376,0.2121646851301193,0.186651200056076,0.1196630746126175,0.03366191685199738,-0.05774101987481117,-0.08618427067995071,-0.04712057858705521,3.051850944757462e-05,0.0237739197909832,0.03299050778150558,0.02996917627751827,0.01055940426886082,0.009582811966538429,-0.04519791156053543,-0.1302224844694138,-0.1590319573879242,-0.13080233335495,-0.05502487346529961,-0.03723258152604103,-0.07525864243507385,-0.1621753573417664,-0.2278817147016525,-0.2358165234327316,-0.251808226108551,-0.2810144424438477,-0.2808618545532227,-0.2574236392974854,-0.2436902970075607,-0.2424695640802383,-0.2375560849905014,-0.3084200620651245,-0.4454176425933838,-0.557542622089386,-0.5839106440544128,-0.5316629409790039,-0.4489883184432983,-0.3670766353607178,-0.3404645025730133,-0.3739738166332245,-0.4679097831249237,-0.5025787949562073,-0.4296700954437256,-0.3167515993118286,-0.2169865965843201,-0.1848811358213425,-0.2661214172840118,-0.3193456828594208,-0.3021942675113678,-0.2529679238796234,-0.221594899892807,-0.1648609936237335,-0.0632953867316246,0.07763908803462982,0.1885433495044708,0.1787163913249969,0.1039460450410843,0.05832087248563766,0.06878872215747833,0.1322367042303085,0.1718192100524902,0.1880245357751846,0.1926328390836716,0.1542100310325623,0.1674855798482895,0.2378917783498764,0.3029877543449402,0.2946867346763611,0.2379222959280014,0.2446058541536331,0.2244636416435242,0.1161534488201141,-0.02975554764270782,-0.1366618871688843,-0.1788079440593719,-0.1951353549957275,-0.1688283979892731,-0.06439405679702759,0.02502517774701118,0.04968413338065147,0.04184087738394737,0.06469924002885818,0.1726126968860626,0.3031403422355652,0.3710135221481323,0.3745536804199219,0.3152256906032562,0.2122562378644943,0.1000701934099197,0.02539139986038208,0.06457716971635818,0.2015442401170731,0.3149815499782562,0.3874019682407379,0.3687856793403625,0.2984099984169006,0.2616657018661499,0.281838446855545,0.2587664425373077,0.2004760950803757,0.1689199507236481,0.2056642323732376,0.2222357839345932,0.2279732674360275,0.1629383265972137,0.0240485854446888,-0.08093509078025818,-0.05838190764188766,0.01174962613731623,0.02975554764270782,0.04422131925821304,-0.005401776172220707,-0.1183202639222145,-0.1810052841901779,-0.1640980243682861,-0.1316568553447723,-0.1527451425790787,-0.1116977483034134,-0.08807642012834549,-0.1183202639222145,-0.146092101931572,-0.160985141992569,-0.1783806830644608,-0.1999572813510895,-0.1454512178897858,-0.08163700997829437,-0.02954191714525223,0.0009155552834272385,0.02649006620049477,0.05380413308739662,0.0477004311978817,0.08819849044084549,0.1511276662349701,0.2276375591754913,0.3252967894077301,0.4155400395393372,0.4856715500354767,0.491073340177536,0.4794152677059174,0.4763329029083252,0.5146030783653259,0.573656439781189,0.5421003103256226,0.4451735019683838,0.3497115969657898,0.287209689617157,0.287118136882782,0.3133640587329865,0.3520309925079346,0.3456831574440002,0.3075350224971771,0.2660603523254395,0.2151860147714615,0.14120914041996,0.05026398599147797,0.007507553324103355,-0.0157170332968235,-0.01928769797086716,-0.04309213533997536,-0.07553330808877945,-0.1343119591474533,-0.1776482462882996,-0.1787774264812469,-0.171147808432579,-0.1923886835575104,-0.2244026064872742,-0.2073122411966324,-0.1910763829946518,-0.2129581570625305,-0.2494277805089951,-0.2653279304504395,-0.2656636238098145,-0.2745445072650909,-0.269142746925354,-0.2479628920555115,-0.2047181576490402,-0.1517075151205063,-0.1098055988550186,-0.1066316738724709,-0.1250953674316406,-0.1537522524595261,-0.223944827914238,-0.2862941324710846,-0.2975859940052032,-0.2557145953178406,-0.1843012720346451,-0.1266518086194992,-0.06506546586751938,-0.01080355234444141,0.01077303383499384,0.01290932949632406,0.03012176975607872,0.04904324561357498,0.05679494515061378,0.05395672470331192,0.03741569444537163,0.05008087307214737,0.1192358136177063,0.1629688441753387,0.1487167030572891,0.1430707722902298,0.1574144661426544,0.1672414392232895,0.1203955188393593,0.09134189784526825,0.1240272223949432,0.1656544655561447,0.2185735702514648,0.2575762271881104,0.2498550415039062,0.2237006723880768,0.2008728235960007,0.1916867643594742,0.236976221203804,0.365245521068573,0.5144810080528259,0.5910214781761169,0.6047242879867554,0.5816828012466431,0.5671254396438599,0.5471053123474121,0.5299233794212341,0.52146977186203,0.4925992488861084,0.4554582238197327,0.413495272397995,0.3437299728393555,0.2625812590122223,0.2297128140926361,0.2354197800159454,0.2597430348396301,0.2201605290174484,0.1054719686508179,0.0199591051787138,-0.005340739153325558,-0.01931821741163731,-0.05340739339590073,-0.08783227205276489,-0.06421094387769699,-0.04919583722949028,-0.04971465095877647,-0.08584856986999512,-0.1154820397496223,-0.08914456516504288,-0.02279732748866081,-0.04321420937776566,-0.1636707633733749,-0.2590716183185577,-0.2650227248668671,-0.2708822786808014,-0.2756431698799133,-0.2677388787269592,-0.1882992088794708,-0.1397442519664764,-0.1717581748962402,-0.2121036350727081,-0.2155217081308365,-0.1968138664960861,-0.1666005402803421,-0.1045869290828705,-0.06103701889514923,-0.1016571521759033,-0.1297952234745026,-0.161290317773819,-0.2036194950342178,-0.2120120823383331,-0.1804559528827667,-0.1799066066741943,-0.2220831960439682,-0.2630695402622223,-0.2386547476053238,-0.0949430838227272,-0.007690664380788803,-0.02710043638944626,-0.1098971515893936,-0.1982177197933197,-0.2545548975467682,-0.3097628653049469,-0.317789226770401,-0.2762840688228607,-0.2155522257089615,-0.1973631978034973,-0.241889700293541,-0.2614215612411499,-0.2804040610790253,-0.2891018390655518,-0.2601397633552551,-0.1826532781124115,-0.06167790666222572,0.04425184056162834,0.07431256771087646,0.05078279972076416,0.007324442267417908,0.002685628831386566,0.08932767808437347,0.2032532691955566,0.251808226108551,0.2913907170295715,0.3508712947368622,0.4287240207195282,0.4194769263267517,0.3415326476097107,0.2598040699958801,0.1746269166469574,0.158665731549263,0.2582781314849854,0.3905148506164551,0.4595172107219696,0.4318063855171204,0.3638111650943756,0.2943204939365387,0.2203436344861984,0.171361431479454,0.1004669368267059,0.01330607011914253,-0.06512650102376938,-0.08813745528459549,-0.07477034628391266,-0.08291879296302795,-0.109714038670063,-0.1160924136638641,-0.07342753559350967,-0.1043427810072899,-0.2296517789363861,-0.2430494129657745,-0.2467726618051529,-0.1808221638202667,-0.1595202535390854,-0.1646473556756973,-0.112002931535244,-0.1252479702234268,-0.2060914933681488,-0.2625812590122223,-0.2681966722011566,-0.2310556322336197,-0.1204870790243149,0.003997924737632275,0.1368755102157593,0.3120517730712891,0.4600970447063446,0.4567705392837524,0.4189275801181793,0.3974730670452118,0.3994872868061066,0.4265572130680084,0.4917142391204834,0.5336466431617737,0.5442671179771423,0.5153355598449707,0.443769633769989,0.3888363242149353,0.4225898087024689,0.4716025292873383,0.4904324412345886,0.5542771816253662,0.669759213924408,0.6572466492652893,0.447798103094101,0.2512588798999786,0.1958983093500137,0.2487258464097977,0.1871700137853622,-0.00555436871945858,-0.0555436871945858,-0.05734428018331528,-0.01339762564748526,0.03598132357001305,0.01715140230953693,-0.06094546243548393,-0.06283760815858841,-0.06476027518510818,-0.06668294221162796,-0.06866664439439774,-0.0711386427283287,-0.07367168366909027,-0.07574693858623505,-0.07782220095396042,-0.07992797344923019,-0.08258308470249176,-0.08529923111200333,-0.0874965637922287,-0.08972442150115967,-0.09198278933763504,-0.09424115717411041,-0.09710989892482758,-0.1000396758317947,-0.1024201214313507,-0.1048005595803261,-0.107211522758007,-0.109653003513813,-0.1127658933401108,-0.1159093007445335,-0.1184423342347145,-0.1210058927536011,-0.123599961400032,-0.1268654465675354,-0.1301919668912888,-0.1328775882720947,-0.1355937421321869,-0.1383403986692429,-0.141117587685585,-0.1446272134780884,-0.1256141811609268,-0.05310220643877983,-0.002288888208568096,0.01651051454246044,0.004272591322660446,-0.01559495832771063,-0.05438398569822311,-0.0951872318983078,-0.05429242923855782,0.0471816174685955,0.1629688441753387,0.3283181190490723,0.4627826809883118,0.5283364653587341,0.5072786808013916,0.4335764646530151,0.4067201614379883,0.4164250493049622,0.4186529219150543,0.4152348339557648,0.4251228272914886,0.5095980763435364,0.6197393536567688,0.7061067819595337,0.6988738775253296,0.6147648692131042,0.5128635764122009,0.3379924893379211,0.241737112402916,0.2470168173313141,0.2781762182712555,0.3155613839626312,0.335398405790329,0.3758659660816193,0.4774926006793976,0.5494857430458069,0.5511032342910767,0.5502182245254517,0.4978484511375427,0.3728141188621521,0.2376476377248764,0.09411908686161041,0.0718100517988205,0.07052827626466751,0.06884975731372833,0.06927701830863953,0.06576738506555557,0.08539079129695892,0.204168826341629,0.3023774027824402,0.3034760653972626,0.2052369713783264,0.1292458921670914,0.1481673568487167,0.1903134286403656,0.2170476466417313,0.2950834631919861,0.3334147036075592,0.2716757655143738,0.1648915112018585,0.08868678659200668,0.08990752696990967,0.1594897359609604,0.1052278205752373,0.07538072019815445,0.07348857074975967,0.0715353861451149,0.1166417449712753,0.1675771325826645,0.189092680811882,0.2363353371620178,0.2705160677433014,0.221503347158432,0.1440168470144272,0.07208471745252609,0.06769005209207535,0.07483138889074326,0.1467635184526443,0.2018799334764481,0.143650621175766,0.06118961051106453,0.05856502056121826,0.0791955292224884,0.1815240979194641,0.241462454199791,0.2115237861871719,0.1455427706241608,0.1138645559549332,0.09375286102294922,0.1438337415456772,0.1226233690977097,0.04522843286395073,0.04205450788140297,0.03878902643918991,0.03546250984072685,0.03118991665542126,0.02682577073574066,0.1178930029273033,0.2729880809783936,0.3081148862838745,0.2458876371383667,0.07254249602556229,0.0199285876005888,0.01605273596942425,0.01208532974123955,0.008056886494159698,0.002899258397519588,-0.002349925227463245,-0.006653035059571266,-0.01104770042002201,-0.0155034027993679,-0.0200506616383791,-0.02587969601154327,-0.0318002887070179,0.04379406198859215,0.1813104599714279,0.1857356429100037,0.2044740170240402,0.2011780142784119,0.07690664380788803,-0.0316476933658123,-0.05121006071567535,-0.05655079707503319,-0.0633869469165802,-0.07034516334533691,-0.07599108666181564,-0.08175908774137497,-0.0876186415553093,0.02432325296103954,0.09430219233036041,0.03012176975607872,0.07473982870578766,0.1565599590539932,0.2050538659095764,0.1686452776193619,0.1506698876619339,0.2136295735836029,0.3207800388336182,0.2833948731422424,0.2420728206634521,0.1928159445524216,0.2542191743850708,0.4419995844364166,0.634113609790802,0.7781914472579956,0.8480178117752075,0.9440595507621765,0.9375286102294922,0.6938077807426453,0.4210943877696991,0.2290108948945999,0.05838190764188766,-0.03787346929311752,-0.04342783987522125,0.2226020097732544,0.5288552641868591,0.4599749743938446,0.03277688100934029,-0.06695760786533356,0.08084353059530258,0.06775109469890594,-0.08383434265851974,-0.09152501076459885,-0.1013519689440727,-0.1113315224647522,-0.1194799616932869,-0.1277504861354828,-0.1361735910177231,-0.1468855887651443,-0.1577806919813156,-0.1666920930147171,-0.1756950616836548,-0.1848506182432175,-0.1941587626934052,-0.2059999406337738,-0.2180242389440536,-0.2278206795454025,-0.2377697080373764,-0.07800531387329102,0.09726248681545258,-0.04681539535522461,-0.1961424648761749,0.334482878446579,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.41261026263237,-0.1877803951501846,-0.1980040967464447,-0.2083803862333298,-0.2189397811889648,-0.2179631888866425,-0.2199774235486984,-0.08072146028280258,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.522415816783905,-0.1273842602968216,-0.1379741877317429,-0.1514328420162201,-0.1651661694049835,-0.176366463303566,-0.1877193450927734,-0.1992858648300171,-0.2110049724578857,-0.2053590565919876,-0.1398968547582626,0.1162144839763641,0.1886959373950958,-0.0791344940662384,-0.1598254293203354,-0.1906186044216156,-0.2986846566200256,-0.3120517730712891,-0.3256324827671051,-0.3394268751144409,-0.23917356133461,-0.1629688441753387,0.1956541687250137,0.4932706654071808,0.538285493850708,0.3180333971977234,-0.013702810741961,-0.2662129700183868,-0.3242286443710327,-0.3814508616924286,-0.3553270101547241,-0.365672767162323,-0.4687337875366211,-0.4892422258853912,-0.5056917071342468,-0.52238529920578,-0.539262056350708,-0.3979003131389618,0.04998932033777237,0.2125919312238693,-0.06530961394309998,-0.4178289175033569,-0.6099429130554199,-0.5553758144378662,-0.01678518019616604,0.5199133157730103,0.616718053817749,0.1873226165771484,-0.2673726677894592,-0.6248970031738281,-0.6925565600395203,-0.712057888507843,-0.7318338751792908,-0.7518540024757385,-0.52092045545578,-0.2361827492713928,0.04828028380870819,0.1809137314558029,0.2108523845672607,0.4245735108852386,0.8665730953216553,0.9440595507621765,0.9440595507621765,0.8099612593650818,0.08270516246557236,-0.5866267681121826,-0.7930539846420288,-0.8145695328712463,-0.8362987041473389,-0.8583330512046814,-0.8341013789176941,-0.6014893054962158,-0.4118167757987976,-0.02758873254060745,0.5507065057754517,0.905117928981781,0.9348430037498474,-0.08304086327552795,-0.8277230262756348,0.478072464466095,0.7994323372840881,-0.4846339225769043,-0.9440900683403015,-0.9119541049003601,-0.7100436687469482,-0.5902279615402222,-0.6611530184745789,-0.8849452137947083,-0.9230323433876038,-0.7717825770378113,-0.4463026821613312,-0.2338023036718369,-0.1508529931306839,0.1582995057106018,-0.2905972599983215,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9280983805656433,-0.903622567653656,-0.9440900683403015,-0.9440900683403015,-0.4874416291713715,-0.2165288180112839,-0.4662922918796539,-0.8009277582168579,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.8985564708709717,-0.7278664708137512,-0.6426587700843811,-0.5899838209152222,-0.5789971351623535,-0.4694357216358185,-0.3131504356861115,-0.1878414303064346,-0.03588976711034775,0.05154576152563095,0.05377361550927162,0.0555742047727108,0.05740531533956528,-0.06961271911859512,-0.1402935832738876,-0.1432843953371048,-0.1452986299991608,-0.1480758041143417,-0.1178930029273033,-0.01474044006317854,0.04992828145623207,0.05224768817424774,0.04367198795080185,-0.0314035452902317,-0.113284707069397,-0.1333353668451309,-0.1036103367805481,-0.07065034657716751,0.02002014219760895,0.05349894613027573,0.0554826520383358,0.05749687179923058,0.06002990901470184,0.06262398511171341,0.06472975760698318,0.06686605513095856,0.06900235265493393,0.0711996853351593,0.07397686690092087,0.03469954431056976,-0.0472121350467205,-0.1053193733096123,-0.1099581867456436,-0.110934779047966,-0.111941896378994,-0.1126743406057358,-0.1134678199887276,-0.1142307817935944,-0.1150242611765862,-0.1159398183226585,-0.1168553754687309,-0.1175878196954727,-0.1183202639222145,-0.1190527081489563,-0.1197546347975731,-0.1206701844930649,-0.1215552240610123,-0.1222571507096291,-0.1229285597801208,-0.123599961400032,-0.1244239658117294,-0.1252174377441406,-0.125827819108963,-0.1264992207288742,-0.1270790696144104,-0.1276894509792328,-0.128513440489769,-0.1292458921670914,-0.1297647058963776,-0.1303750723600388,-0.130893886089325,-0.1314432173967361,-0.1321146339178085,-0.1327250003814697,-0.1332132965326309,-0.1336710751056671,-0.1341898888349533,-0.1347392201423645,-0.1352580338716507,-0.1356547772884369,-0.1360820382833481,-0.1364482492208481,-0.1368449926376343,-0.1372417360544205,-0.1376689970493317,-0.1379741877317429,-0.1382488459348679,-0.1384930014610291,-0.1387371420860291,-0.1390118151903152,-0.1392254382371902,-0.1394085586071014,-0.1396221816539764,-0.1396832168102264,-0.1398663222789764,-0.1399578899145126,-0.1400494426488876,-0.1400189250707626,-0.1400494426488876,-0.1400189250707626,-0.1399578899145126,-0.1398663222789764,-0.1397137343883514,-0.1395916640758514,-0.1394085586071014,-0.1392559558153152,-0.1389202624559402,-0.1386455893516541,-0.1383098810911179,-0.1380352228879929,-0.1376384794712067,-0.1371807008981705,-0.1366618871688843,-0.1362041085958481,-0.1356852948665619,-0.1351359635591507,-0.1345866322517395,-0.1338846981525421,-0.1330301761627197,-0.1323587745428085,-0.1316568553447723,-0.130893886089325,-0.1298867762088776,-0.1288186311721802,-0.1279641091823578,-0.1270485520362854,-0.126071959733963,-0.1251564025878906,-0.1238135918974876,-0.1224402636289597,-0.1213110759854317,-0.1201208531856537,-0.1188390776515007,-0.1176183372735977,-0.1159093007445335,-0.1142002642154694,-0.1127658933401108,-0.1112704873085022,-0.1097445636987686,-0.1077608540654182,-0.1057161167263985,-0.1040375977754593,-0.1022370085120201,-0.1004364117980003,-0.09866634011268616,-0.09628589451313019,-0.09384441375732422,-0.09179967641830444,-0.08972442150115967,-0.0875576063990593,-0.08539079129695892,-0.08255256712436676,-0.0796227902173996,-0.07727286964654922,-0.07477034628391266,-0.07232886552810669,-0.06900235265493393,-0.06567583233118057,-0.06277657300233841,-0.05957213044166565,-0.05508590862154961,-0.04675435647368431,0.08838160336017609,-0.1238135918974876,-0.7233802080154419,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.005432294681668282,0.02081362344324589,0.02572710439562798,0.03070162050426006,0.03576769307255745,-0.04123050719499588,-0.0869472324848175,-0.08435316383838654,-0.08093509078025818,-0.07754753530025482,-0.07403790205717087,-0.06955168396234512,-0.06494338810443878,-0.06115909293293953,-0.05728324130177498,-0.05334635451436043,-0.04934842884540558,-0.04416028410196304,-0.03888058289885521,-0.03457747027277946,-0.03018280677497387,-0.02569658495485783,-0.0199591051787138,-0.0140690328553319,-0.009277626872062683,-0.004333628341555595,0.0006408886983990669,0.005737479776144028,0.01229895930737257,0.01892147585749626,0.02426221594214439,0.02981658466160297,0.03537095338106155,0.04113895073533058,0.04843287542462349,0.0558793917298317,0.06192205473780632,0.06814783066511154,0.07437361031770706,0.08239997923374176,0.09054841846227646,0.09720145165920258,0.1039765626192093,0.110843226313591,0.1178319677710533,0.1267128586769104,0.1357463300228119,0.1430707722902298,0.1505478024482727,0.1581164002418518,0.1658375859260559,0.1756340265274048,0.1856135725975037,0.193670466542244,0.2019104659557343,0.2102115005254745,0.2208014130592346,0.2316049635410309,0.2403027415275574,0.2491225898265839,0.2580645084381104,0.2670674622058868,0.2806482017040253,0.2926114797592163,0.3030487895011902,0.3079012334346771,0.2717673182487488,0.4401074349880219,0.4547868371009827,0.4622333347797394,0.4664449095726013,-0.9440900683403015,-0.8318125009536743,0.1928159445524216,0.3806878924369812,0.3718070089817047,0.382610559463501,0.3935361802577972,0.4046143889427185,0.4186224043369293,0.4328745305538177,0.4444105327129364,0.4561296403408051,0.4679403007030487,0.4829249083995819,0.4981231093406677,0.5104220509529114,0.5229346752166748,0.5355387926101685,0.5482650399208069,0.5643787980079651,0.5807672142982483,0.5940427780151367,0.6074404120445251,0.6210211515426636,0.634693443775177,0.652058482170105,0.669606626033783,0.6838587522506714,0.6981719136238098,0.712759792804718,0.730521559715271,0.748832643032074,0.7629322409629822,0.7746208310127258,0.7779167890548706,0.9016388654708862,0.2627338469028473,-0.0004272591322660446,-0.008941923268139362,-0.01278725545853376,-0.01141392253339291,-0.0101016266271472,-0.006408886983990669,-0.01333658862859011,-0.01580858789384365,-0.01809747703373432,-0.01492355111986399,-0.0008239997550845146,0.003326517529785633,0.003845332190394402,0.0009460737928748131,-0.0006714072078466415,-0.001434369944036007,0.003509628586471081,0.008545182645320892,0.007629627361893654,0.01251258887350559,0.01449629198759794,0.01275673694908619,0.01290932949632406,0.01678518019616604,0.01742606982588768,0.02072206884622574,0.02044740132987499,0.01245155185461044,0.004150517284870148,0.002105777151882648,0.009063997305929661,0.008484145626425743,0.01065095979720354,0.005767998285591602,-0.006897183135151863,-0.005859553813934326,-0.007507553324103355,-0.01135288551449776,-0.01043733023107052,-0.01077303383499384,-0.002349925227463245,-0.001861629076302052,-0.004547257907688618,-0.003357036039233208,-0.007599108852446079,-0.008911404758691788,-0.006530961021780968,-0.004119998775422573,0.001953184604644775,0.0009765923023223877,-0.002349925227463245,-0.0006103701889514923,-0.002899258397519588,-0.009643848985433578,-0.01217688526958227,-0.01229895930737257,-0.003936887718737125,0.0003051850944757462,-0.006500442512333393,-0.01397747732698917,-0.01342814415693283,-0.003234962001442909,-0.002685628831386566,-0.005645924247801304,-0.006103701889514923,-0.0006103701889514923,0.007202368229627609,0.00476088747382164,0.002746665850281715,0.002868739888072014,0.0001831110566854477,0.001953184604644775,0.004669331945478916,0.003662221133708954,0.002624591812491417,0.002410962246358395,0.001068147830665112,0.004669331945478916,0.009063997305929661,0.01797540299594402,0.0202032532542944,0.01760918088257313,0.0140690328553319,0.007904293946921825,-3.051850944757462e-05,0.001922666095197201,-0.002807702869176865,-0.003326517529785633,-0.0006714072078466415,-0.003997924737632275,-0.002929776906967163,-0.0006103701889514923,0.001678518019616604,-9.155552834272385e-05,-0.0101016266271472,-0.01220740377902985,-0.006195257417857647,-0.004638813436031342,0.001800592057406902,-0.0007324442267417908,-0.0003357036039233208,0.002899258397519588,-0.007477034814655781,-0.01293984800577164,-0.01431318093091249,-0.01272621843963861,-0.006073183380067348,0.0039674062281847,0.004181035794317722,0.002166814170777798,0.006683553569018841,0.005096591077744961,-0.0005493331700563431,0.0005188146606087685,0.006897183135151863,0.01062044128775597,0.0140690328553319,0.01922666095197201,0.02032532729208469,0.0161137729883194,0.01229895930737257,0.01040681172162294,0.01013214513659477,0.01498458813875914,0.013702810741961,0.01284829247742891,0.008575701154768467,0.0004577776417136192,0.001495406962931156,0.003875850699841976,0.0003662221133708954,9.155552834272385e-05,-0.0008850367739796638,-0.0004272591322660446,-0.0009155552834272385,-0.0001220740377902985,-0.00238044373691082,-0.005005035549402237,-0.0090]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>ar15_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[-0.08978545665740967,-0.08273568004369736,-0.07058931142091751,-0.05722220614552498,-0.04422131925821304,-0.03723258152604103,-0.04354991391301155,-0.05887020379304886,-0.06817834824323654,-0.06231879815459251,-0.05078279972076416,-0.04953154176473618,-0.05780205875635147,-0.06714072078466415,-0.0711996853351593,-0.06506546586751938,-0.04013184085488319,-0.01770073547959328,-0.0237739197909832,-0.04348887503147125,-0.05844294652342796,-0.06595049798488617,-0.06924650073051453,-0.06289865076541901,-0.05969420447945595,-0.05990783497691154,-0.07284767925739288,-0.0955229327082634,-0.1041901931166649,-0.1122470796108246,-0.1160008534789085,-0.1113010048866272,-0.09390545636415482,-0.06756798177957535,-0.06042664870619774,-0.0636005774140358,-0.06274605542421341,-0.05743583664298058,-0.05475020781159401,-0.06076235324144363,-0.07260353118181229,-0.08322397619485855,-0.08127079159021378,-0.07522812485694885,-0.06790368258953094,-0.04681539535522461,-0.01760918088257313,0.01492355111986399,0.04617450386285782,0.06744590401649475,0.06167790666222572,0.04211554303765297,0.03674428537487984,0.0394604317843914,0.04705954343080521,0.0477614663541317,0.03778191655874252,0.03872798755764961,0.04589983820915222,0.05377361550927162,0.06308175623416901,0.0713217556476593,0.0872829407453537,0.1028778925538063,0.113193154335022,0.1122470796108246,0.1009552329778671,0.08795434236526489,0.0869472324848175,0.08200323581695557,0.0715659037232399,0.0634784996509552,0.06500442326068878,0.06744590401649475,0.05658131837844849,0.04257332161068916,0.03848383948206902,0.04666280001401901,0.06457716971635818,0.07882931083440781,0.08551286160945892,0.08014160394668579,0.06900235265493393,0.05624561384320259,0.05014191195368767,0.06088442727923393,0.06973479688167572,0.06888027489185333,0.07199316471815109,0.07986693829298019,0.0953703448176384,0.1181981861591339,0.1291238069534302,0.128604993224144,0.1233863309025764,0.1100802645087242,0.0871303454041481,0.06808679550886154,0.05935849994421005,0.06064027920365334,0.06234931573271751,0.05389568954706192,0.03808709979057312,0.02847377024590969,0.02606280706822872,0.02212592028081417,-0.007232886739075184,-0.04715109616518021,-0.06558427959680557,-0.07022309303283691,-0.06997894495725632,-0.07715079188346863,-0.09747611731290817,-0.1050141900777817,-0.1049226373434067,-0.1087679713964462,-0.1160008534789085,-0.1249732971191406,-0.1338541805744171,-0.1387371420860291,-0.1375164091587067,-0.126071959733963,-0.1062349304556847,-0.08127079159021378,-0.0876796767115593,-0.1118503361940384,-0.1278420388698578,-0.1323587745428085,-0.123630478978157,-0.1101412996649742,-0.1024201214313507,-0.09115878492593765,-0.07837153226137161,-0.07022309303283691,-0.06164738908410072,-0.06299020349979401,-0.05954161286354065,-0.0316782146692276,-0.00198370311409235,0.01654103212058544,0.01522873621433973,0.002563554793596268,0.004333628341555595,0.005920590832829475,-0.0005188146606087685,-0.006408886983990669,-0.004089480265974998,0.01776177249848843,0.04345835745334625,0.06695760786533356,0.08838160336017609,0.1031830832362175,0.1098666340112686,0.1047395244240761,0.09292886406183243,0.0869167149066925,0.09173864126205444,0.0950956791639328,0.079256571829319,0.06668294221162796,0.07321390509605408,0.09479048848152161,0.1199987828731537,0.1469771414995193,0.1629383265972137,0.1645558029413223,0.156224250793457,0.1494491398334503,0.1485030651092529,0.1632740199565887,0.1718192100524902,0.1673635095357895,0.1491439491510391,0.1189001128077507,0.1098971515893936,0.128330335021019,0.1385845541954041,0.1324198096990585,0.1094393730163574,0.08590960502624512,0.08154545724391937,0.08172857016324997,0.07196264714002609,0.0635395348072052,0.06225775927305222,0.05847346410155296,0.04113895073533058,0.01657155156135559,0.00991851557046175,0.01641895808279514,0.02710043638944626,0.02362132631242275,-0.002563554793596268,-0.0235297717154026,-0.02395703084766865,-0.01464888453483582,-0.01522873621433973,-0.03057954646646976,-0.0399792492389679,-0.0320139154791832,-0.02096621692180634,-0.01242103334516287,-0.004699850454926491,0.001678518019616604,0.002441480755805969,0.007690664380788803,0.0198065135627985,0.02938932552933693,0.02606280706822872,0.02462843805551529,0.027405621483922,0.02951139956712723,0.03704947233200073,0.04315317422151566,0.04928739368915558,0.05368205904960632,0.05236976221203804,0.05310220643877983,0.05352946743369102,0.06537064909934998,0.08426160365343094,0.08667256683111191,0.08093509078025818,0.07049775868654251,0.05880916863679886,0.03811761736869812,0.01553392130881548,0.0141911068931222,0.01361125521361828,0.003509628586471081,-0.0101016266271472,-0.02578814141452312,-0.039704579859972,-0.04443494975566864,-0.04208502545952797,-0.03125095367431641,-0.01904354989528656,-0.02227851189672947,-0.04422131925821304,-0.06997894495725632,-0.09070101380348206,-0.1027863398194313,-0.1017181947827339,-0.09393597394227982,-0.08447523415088654,-0.0713827908039093,-0.06039613112807274,-0.04968413338065147,-0.05493331700563431,-0.07684560865163803,-0.08243049681186676,-0.07065034657716751,-0.04962309822440147,-0.0392468050122261,-0.0559404268860817,-0.0718710869550705,-0.08102664351463318,-0.08432263880968094,-0.08603167533874512,-0.0868251621723175,-0.07797478884458542,-0.06860560923814774,-0.07007049769163132,-0.08658101409673691,-0.1065095961093903,-0.1026642695069313,-0.06918545812368393,-0.04986724629998207,-0.04849391058087349,-0.04589983820915222,-0.02887050993740559,-0.02108829095959663,-0.0237739197909832,-0.01904354989528656,-0.01016266364604235,-0.0007629627361893654,0.002899258397519588,-0.004913480021059513,-0.02209540084004402,-0.04300057888031006,-0.05493331700563431,-0.05911435186862946,-0.05801568552851677,-0.05160680040717125,-0.04397717118263245,-0.02993865869939327,-0.02096621692180634,-0.02288888208568096,-0.04260383918881416,-0.0555742047727108,-0.06183050200343132,-0.07284767925739288,-0.09305093437433243,-0.1140476688742638,-0.1204565539956093,-0.1100497469305992,-0.08926664292812347,-0.07205419987440109,-0.07367168366909027,-0.08954130858182907,-0.09793389588594437,-0.09976501017808914,-0.09985656291246414,-0.1010773032903671,-0.1176183372735977,-0.143467515707016,-0.1521347761154175,-0.145939514040947,-0.143681138753891,-0.1444441080093384,-0.1417889893054962,-0.1373027712106705,-0.1318704783916473,-0.1331217437982559,-0.143375962972641,-0.1499374359846115,-0.1491439491510391,-0.1416364014148712,-0.1332438141107559,-0.1280556619167328,-0.1200293004512787,-0.1135288551449776,-0.1022980436682701,-0.08377330750226974,-0.06613361090421677,-0.05844294652342796,-0.05279702320694923,-0.04199346899986267,-0.03415021300315857,-0.04651020839810371,-0.05951109528541565,-0.04934842884540558,-0.01144444104284048,0.01651051454246044,0.02215643785893917,0.02633747458457947,0.03762932121753693,0.05023346841335297,0.05328531935811043,0.04580828174948692,0.04263435676693916,0.03415021300315857,0.02172917872667313,0.002349925227463245,-0.02710043638944626,-0.05236976221203804,-0.0556657612323761,-0.04406872764229774,-0.03753776848316193,-0.04824976250529289,-0.06637775897979736,-0.06924650073051453,-0.06561479717493057,-0.05230872705578804,-0.04257332161068916,-0.0557573176920414,-0.08481093496084213,-0.1019013002514839,-0.09964293241500854,-0.08636738359928131,-0.07409894466400146,-0.07614368200302124,-0.08014160394668579,-0.06442457437515259,-0.02526932582259178,0.006164738908410072,0.005767998285591602,-0.01516769919544458,-0.006591998040676117,0.03118991665542126,0.0716879814863205,0.09070101380348206,0.09091463685035706,0.09955137968063354,0.1142918169498444,0.1216162592172623,0.1241493001580238,0.1337321102619171,0.1514328420162201,0.1643116623163223,0.1732230633497238,0.1781975775957108,0.1800592094659805,0.1803643852472305,0.1822260171175003,0.1774956583976746,0.1666005402803421,0.1749015748500824,0.1984618604183197,0.2163762301206589,0.2173223048448563,0.2113101631402969,0.2078005373477936,0.2015137225389481,0.1879024654626846,0.1673024743795395,0.1530503183603287,0.1499679535627365,0.1522568464279175,0.1542100310325623,0.1441083997488022,0.128635510802269,0.1207312270998955,0.1192663386464119,0.1149937435984612,0.1051362678408623,0.09475997090339661,0.08099612593650818,0.07208471745252609,0.06772056967020035,0.0557878352701664,0.03704947233200073,0.01718192175030708,-0.004486220888793468,-0.01467940304428339,-0.01132236700505018,0.0002746665850281715,0.01617481000721455,0.03018280677497387,0.02966399118304253,0.01748710684478283,-0.003418073058128357,-0.02584917843341827,-0.04254280403256416,-0.03869746997952461,-0.02917569503188133,-0.02188177220523357,-0.01702932827174664,-0.01239051483571529,-0.01086458936333656,-0.007904293946921825,-0.001892147585749626,0.003143406473100185,0.01391644030809402,0.0316782146692276,0.03375347331166267,0.027375103905797,0.02603228949010372,0.02697836235165596,0.01892147585749626,0.02758873254060745,0.04992828145623207,0.05221717059612274,0.04489272832870483,0.0397351011633873,0.0392773225903511,0.04336680099368095,0.04486221075057983,0.04214606061577797,0.03466902673244476,0.02780236303806305,0.03439436107873917,0.04913480207324028,0.05294961482286453,0.04330576583743095,0.01928769797086716,-0.006622516550123692,-0.02911465801298618,-0.04843287542462349,-0.05948057398200035,-0.06393627822399139,-0.06491287052631378,-0.06775109469890594,-0.06811731308698654,-0.06390576064586639,-0.06888027489185333,-0.08792382478713989,-0.09741508215665817,-0.08005005121231079,-0.0637226477265358,-0.06512650102376938,-0.07217627763748169,-0.0710776075720787,-0.06494338810443878,-0.05679494515061378,-0.05334635451436043,-0.06100650131702423,-0.07593005150556564,-0.08505508303642273,-0.06476027518510818,-0.04022339731454849,-0.04052858054637909,-0.05969420447945595,-0.08069094270467758,-0.08902249485254288,-0.08838160336017609,-0.07861568033695221,-0.06942960619926453,-0.06967375427484512,-0.08062990009784698,-0.09640797227621078,-0.09735404700040817,-0.08276619762182236,-0.07519760727882385,-0.0711691677570343,-0.07547227293252945,-0.09161656349897385,-0.08633686602115631,-0.07446516305208206,-0.06637775897979736,-0.05801568552851677,-0.05734428018331528,-0.06280709058046341,-0.07022309303283691,-0.06897183507680893,-0.06451612710952759,-0.06686605513095856,-0.07025361061096191,-0.06479079276323318,-0.05099643021821976,-0.03338725119829178,-0.01065095979720354,0.006408886983990669,0.0115359965711832,0.001434369944036007,-0.009552293457090855,-0.01123081147670746,0.001647999510169029,0.01950132846832275,0.03326517716050148,0.03540147095918655,0.04251228272914886,0.05404828116297722,0.05951109528541565,0.05819879844784737,0.0558488741517067,0.05923642590641975,0.05899227783083916,0.05279702320694923,0.05667287111282349,0.07211523503065109,0.06921598315238953,0.04583880305290222,0.01901303231716156,0.007263405248522758,0.01867732778191566,0.04629657790064812,0.06134220585227013,0.06540116667747498,0.06851405650377274,0.0714743509888649,0.05633717030286789,0.0398876927793026,0.0471816174685955,0.05847346410155296,0.06030457466840744,0.04977568984031677,0.03305154666304588,0.02371288277208805,0.02545243687927723,0.03476058319211006,0.04962309822440147,0.06030457466840744,0.06207465007901192,0.07193212956190109,0.08484145998954773,0.09671315550804138,0.1050752252340317,0.1041901931166649,0.09298989921808243,0.0791650116443634,0.07358012348413467,0.079256571829319,0.08893093466758728,0.1010162681341171,0.1046479716897011,0.09753715991973877,0.08630634844303131,0.07687612622976303,0.07562486827373505,0.08795434236526489,0.0951261967420578,0.08029419928789139,0.05313272401690483,0.0318308062851429,0.02526932582259178,0.03445539623498917,0.04425184056162834,0.04544205963611603,0.03524887934327126,0.01757866144180298,0.0008239997550845146,-0.005462813191115856,-0.009643848985433578,-0.01715140230953693,-0.01913510635495186,-0.0195623654872179,-0.0238044373691082,-0.03707998991012573,-0.06015198305249214,-0.08276619762182236,-0.09759819507598877,-0.09656056761741638,-0.09039582312107086,-0.09402752667665482,-0.1020538955926895,-0.1115451529622078,-0.1117893010377884,-0.107211522758007,-0.1068147867918015,-0.09439375251531601,-0.08474989980459213,-0.0954618975520134,-0.1127658933401108,-0.1253395229578018,-0.1214941889047623,-0.1152378916740417,-0.1130405589938164,-0.11444441229105,-0.1122775971889496,-0.1042817458510399,-0.1038850098848343,-0.1039460450410843,-0.09918515384197235,-0.08401745557785034,-0.05499435588717461,-0.03897213563323021,-0.0399182103574276,-0.04806665331125259,-0.04910428076982498,-0.04287850484251976,-0.0399487279355526,-0.0397961363196373,-0.03537095338106155,-0.03234962001442909,-0.02362132631242275,0.004272591322660446,0.0313730277121067,0.05108798667788506,0.0709250196814537,0.08105716109275818,0.07309182733297348,0.05752738937735558,0.04544205963611603,0.04422131925821304,0.04931791126728058,0.04998932033777237,0.04947050288319588,0.05200354009866714,0.06076235324144363,0.07284767925739288,0.08368175476789474,0.0872829407453537,0.08450575172901154,0.09628589451313019,0.1187169998884201,0.1374858915805817,0.145817443728447,0.1479842513799667,0.1427045464515686,0.1340983361005783,0.1217688545584679,0.1104464828968048,0.1065401136875153,0.1040070801973343,0.1059602648019791,0.09421063959598541,0.0711691677570343,0.04870754107832909,0.031434066593647,0.02154606766998768,0.02169866114854813,0.02639851160347462,0.0313425101339817,0.02874843589961529,0.02117984555661678,0.02154606766998768,0.01284829247742891,-0.005737479776144028,-0.01016266364604235,-0.001037629321217537,0.001739555038511753,0.002410962246358395,0.009826960042119026,0.02108829095959663,0.0278939176350832,0.03122043609619141,0.03265480697154999,0.02871791832149029,0.03012176975607872,0.0279854740947485,0.01602221839129925,0.005859553813934326,0.00039674062281847,0.0007019257172942162,0.002594073303043842,0.004638813436031342,0.01052888575941324,0.02258369699120522,0.02993865869939327,0.03759880363941193,0.03881954401731491,0.02880947291851044,0.006866664625704288,-0.01516769919544458,-0.01034577470272779,0.007904293946921825,0.01760918088257313,0.01046784874051809,-0.006561479531228542,-0.02279732748866081,-0.03582873195409775,-0.04428235813975334,-0.0398876927793026,-0.02533036284148693,-0.01535081025213003,-0.01446577347815037,-0.007965330965816975,0.002471999265253544,0.01416058838367462,0.0281075481325388,0.03009125031530857,0.01763969846069813,0.01614429242908955,0.02731406688690186,0.03701895102858543,0.0399487279355526,0.05496383458375931,0.08172857016324997,0.09210485965013504,0.09759819507598877,0.1038239672780037,0.1154515221714973,0.1352580338716507,0.1495712101459503,0.1597643941640854,0.1641895771026611,0.1614429205656052,0.1672719568014145,0.1823480874300003,0.1920224577188492,0.1949217170476913,0.189001128077507,0.1841181665658951,0.1850337237119675,0.1932737231254578,0.2106082290410995,0.2326731234788895,0.2406994849443436,0.2243720889091492,0.1850337237119675,0.1578112095594406,0.1452681124210358,0.1337321102619171,0.1251258850097656,0.1474349200725555,0.1771904677152634,0.1658375859260559,0.1300698816776276,0.09897152334451675,0.08822900801897049,0.08993804454803467,0.07809686660766602,0.0558183528482914,0.03524887934327126,0.01760918088257313,-0.01895199529826641,-0.06634724140167236,-0.1046784892678261,-0.1300698816776276,-0.1349833607673645,-0.1428571492433548,-0.171544536948204,-0.2068239450454712,-0.2219306081533432,-0.2159794867038727,-0.2072817236185074,-0.2086245268583298,-0.2375255525112152,-0.2670369446277618,-0.28235724568367,-0.2864162027835846,-0.2881862819194794,-0.3051851093769073,-0.3249000608921051,-0.3387554585933685,-0.347331166267395,-0.3440351486206055,-0.3326212465763092,-0.3111667335033417,-0.2990203499794006,-0.3030182719230652,-0.3082979917526245,-0.3069856762886047,-0.3037507236003876,-0.2992644906044006,-0.287575900554657,-0.2526017129421234,-0.2092349082231522,-0.1838435083627701,-0.1707510650157928,-0.156224250793457,-0.143772691488266,-0.1279030740261078,-0.1138645559549332,-0.1050752252340317,-0.08923612534999847,-0.07483138889074326,-0.06173894554376602,-0.0472121350467205,-0.03756828606128693,-0.04077272862195969,-0.06146427989006042,-0.07721182703971863,-0.0791344940662384,-0.07223731279373169,-0.05969420447945595,-0.04144413769245148,-0.02703939937055111,-0.006378368474543095,0.01159703359007835,-0.005706961266696453,-0.0473952442407608,-0.09063997119665146,-0.09915463626384735,-0.08432263880968094,-0.079256571829319,-0.08502456545829773,-0.09793389588594437,-0.09851375222206116,-0.09454634040594101,-0.09018219262361526,-0.08041626960039139,-0.08960234373807907,-0.09979552775621414,-0.08816797286272049,-0.07852412760257721,-0.07782220095396042,-0.09201330691576004,-0.1036103367805481,-0.1022675260901451,-0.09631641954183578,-0.0868251621723175,-0.08807642012834549,-0.09585864096879959,-0.09277626872062683,-0.0790734589099884,-0.06079287081956863,-0.03692739829421043,-0.005890072323381901,0.02044740132987499,0.03097628802061081,0.02191228978335857,0.01721243932843208,0.01879940181970596,0.02255317941308022,0.03601184114813805,0.05941953882575035,0.0711691677570343,0.07193212956190109,0.0717795342206955,0.06689657270908356,0.06692709028720856,0.09164708107709885,0.1172521114349365,0.1166722625494003,0.09585864096879959,0.07208471745252609,0.07397686690092087,0.107058934867382,0.1156041175127029,0.1073030829429626,0.09781182557344437,0.09659108519554138,0.1046784892678261,0.1074861884117126,0.1098666340112686,0.1191442608833313,0.1347392201423645,0.1495712101459503,0.1472212970256805,0.1322061866521835,0.1081881150603294,0.08795434236526489,0.08120975643396378,0.1056855991482735,0.1456648409366608,0.1532639563083649,0.1382793635129929,0.1176793724298477,0.09854426980018616,0.08359019458293915,0.06707968562841415,0.0556962788105011,0.03787346929311752,0.008484145626425743,-0.01760918088257313,-0.0161137729883194,-0.01034577470272779,-0.01553392130881548,-0.01800592057406902,-0.0274971779435873,-0.04327524825930595,-0.04113895073533058,-0.0319223627448082,-0.0476699136197567,-0.09012115746736526,-0.13068026304245,-0.1415753662586212,-0.1356242597103119,-0.1373332887887955,-0.158909872174263,-0.186437577009201,-0.1961424648761749,-0.1807306110858917,-0.1636097282171249,-0.1530808508396149,-0.1481673568487167,-0.143772691488266,-0.1313821822404861,-0.126102477312088,-0.1330607086420059,-0.1339762508869171,-0.1356852948665619,-0.1554002463817596,-0.1730094254016876,-0.1652882546186447,-0.145878478884697,-0.1231421828269958,-0.1118808537721634,-0.1407818794250488,-0.1667836606502533,-0.1569261699914932,-0.1331827789545059,-0.1066316738724709,-0.09082308411598206,-0.0877407118678093,-0.08072146028280258,-0.05734428018331528,-0.02713095583021641,-0.00714133121073246,0.00079348124563694,-0.002166814170777798,-0.02014221623539925,-0.03515732288360596,-0.03512680530548096,-0.02465895563364029,-0.003265480510890484,0.01754814386367798,0.02551347389817238,0.02545243687927723,0.02917569503188133,0.03900265693664551,0.04550309851765633,0.03561510145664215,0.02444532699882984,0.02658162266016006,0.03466902673244476,0.03445539623498917,0.01989806815981865,0.008880886249244213,0.005767998285591602,0.007629627361893654,0.01846369914710522,0.03781243413686752,0.05026398599147797,0.0556047260761261,0.06570634990930557,0.07879879325628281,0.08789330720901489,0.09628589451313019,0.107058934867382,0.1301003992557526,0.1580553650856018,0.1831720918416977,0.1892452836036682,0.1963560879230499,0.2162541598081589,0.2291634827852249,0.2253181487321854,0.2226325273513794,0.2349620014429092,0.234199047088623,0.2247993350028992,0.2289803773164749,0.2312997877597809,0.2203131169080734,0.2001403868198395,0.176152840256691,0.1602221727371216,0.156254768371582,0.1570177376270294,0.1531418859958649,0.1524399518966675,0.1471297293901443,0.1421857327222824,0.1393169909715652,0.1344950646162033,0.1286965608596802,0.1118198186159134,0.09421063959598541,0.07190161198377609,0.0555436871945858,0.06009094417095184,0.06402783095836639,0.05267494916915894,0.0281075481325388,0.00991851557046175,0.008270516060292721,0.02618488110601902,0.04876857995986938,0.04892117157578468,0.03607288002967834,0.02410962246358395,0.01907406933605671,0.03222754597663879,0.05984679609537125,0.07498397678136826,0.08377330750226974,0.08801538497209549,0.079226054251194,0.0711081251502037,0.07980590313673019,0.0949430838227272,0.1116061881184578,0.1269569993019104,0.143406480550766,0.1625415831804276,0.1606799513101578,0.1443830728530884,0.1297341883182526,0.1315958201885223,0.1616870611906052,0.1794488430023193,0.160893589258194,0.1318704783916473,0.113315224647522,0.113315224647522,0.1228369995951653,0.1179540380835533,0.1003143414855003,0.07684560865163803,0.05728324130177498,0.06179998070001602,0.07324442267417908,0.0716879814863205,0.07263405621051788,0.08221686631441116,0.08066041767597198,0.04989776387810707,0.04446546733379364,0.07061982899904251,0.09244056791067123,0.09781182557344437,0.0951872318983078,0.09137241542339325,0.08569597452878952,0.08505508303642273,0.08627582341432571,0.07770012319087982,0.06149479746818542,0.04202398657798767,0.02865688130259514,0.02420117892324924,0.03619495406746864,0.05462813377380371,0.05212561413645744,0.02279732748866081,0.001770073547959328,-0.01556443981826305,-0.0316171757876873,-0.047883540391922,-0.06912442296743393,-0.09790337830781937,-0.1123081147670746,-0.1093173027038574,-0.1103854477405548,-0.1292764097452164,-0.1676686853170395,-0.1883602440357208,-0.1946775764226913,-0.2016663104295731,-0.2268135696649551,-0.2689290940761566,-0.286935031414032,-0.2754295468330383,-0.2509842216968536,-0.2310556322336197,-0.2350840717554092,-0.2641987502574921,-0.2854090929031372,-0.2915433347225189,-0.2839137017726898,-0.2732322216033936,-0.256508082151413,-0.2306588888168335,-0.2049928307533264,-0.1810968369245529,-0.1542405486106873,-0.1208532974123955,-0.1048921197652817,-0.1039155274629593,-0.08377330750226974,-0.0475173182785511,-0.01770073547959328,0.005676442757248878,0.01257362589240074,0.01977599412202835,0.03555406257510185,0.05047761648893356,0.06933805346488953,0.08664204925298691,0.07629627734422684,0.04828028380870819,0.03405865654349327,0.04614398628473282,0.07827997952699661,0.0791039764881134,0.0475173182785511,0.0162358470261097,-0.0001220740377902985,0.004669331945478916,0.02996917627751827,0.05203405767679214,0.04925687611103058,0.03424176946282387,0.007415997795760632,-0.02493362314999104,-0.05508590862154961,-0.06060976162552834,-0.04876857995986938,-0.04553361609578133,-0.05420087277889252,-0.05722220614552498,-0.04275643080472946,-0.02423169650137424,-0.01312295906245708,-0.008575701154768467,-0.006836146116256714,-0.0140690328553319,-0.02157658711075783,-0.02664265967905521,-0.03299050778150558,-0.03344828635454178,-0.03103732503950596,-0.02319406718015671,-0.007721182890236378,0.006591998040676117,0.02487258613109589,0.03457747027277946,0.0159611813724041,-0.009887997061014175,-0.01373332925140858,-0.009063997305929661,-0.0079348124563694,-0.005493331700563431,-0.008575701154768467,-0.01657155156135559,-0.01281777396798134,-0.01040681172162294,-0.02194280922412872,-0.04947050288319588,-0.09439375251531601,-0.1106906309723854,-0.09643848985433578,-0.0872218981385231,-0.08505508303642273,-0.08258308470249176,-0.09298989921808243,-0.1087984889745712,-0.1102328598499298,-0.09680471569299698,-0.07358012348413467,-0.04565569013357162,-0.02429273352026939,-0.0102237006649375,-0.001770073547959328,-0.00238044373691082,-0.02639851160347462,-0.05282754078507423,-0.04669332131743431,-0.01425214391201735,0.027375103905797,0.05856502056121826,0.06445509195327759,0.05389568954706192,0.05066072568297386,0.06265450268983841,0.08478041738271713,0.1091036722064018,0.1091341897845268,0.07217627763748169,0.04531998559832573,0.04263435676693916,0.05429242923855782,0.06769005209207535,0.06537064909934998,0.0634174644947052,0.07214576005935669,0.08374278992414474,0.09192175418138504,0.1004669368267059,0.1199377402663231,0.1371501833200455,0.1269875168800354,0.09408856183290482,0.06399731338024139,0.05755791068077087,0.07428205013275146,0.07770012319087982,0.06472975760698318,0.05612353980541229,0.0637836828827858,0.08273568004369736,0.0954924151301384,0.09076204895973206,0.08059938251972198,0.08182012289762497,0.09094516187906265,0.1068758219480515,0.1211584806442261,0.1313821822404861,0.1242103353142738,0.1115146353840828,0.1123386323451996,0.113254189491272,0.1087679713964462,0.08871730417013168,0.07565538585186005,0.07760857045650482,0.06903287023305893,0.05240027979016304,0.03439436107873917,0.009796441532671452,-0.02117984555661678,-0.05502487346529961,-0.07351908832788467,-0.07071138918399811,-0.05838190764188766,-0.06384472548961639,-0.09262367337942123,-0.1341898888349533,-0.1703238040208817,-0.1828669160604477,-0.1834772825241089,-0.1905270516872406,-0.208990752696991,-0.2273018658161163,-0.2379222959280014,-0.2410962283611298,-0.2399059981107712,-0.2495193332433701,-0.2677999138832092,-0.2630390226840973,-0.2419812679290771,-0.2194891273975372,-0.1989806890487671,-0.186437577009201,-0.1868648380041122,-0.1956541687250137,-0.2036805301904678,-0.2105471938848495,-0.2102725356817245,-0.2060609757900238,-0.2074037939310074,-0.2002624571323395,-0.2012695670127869,-0.2085329741239548,-0.2084414213895798,-0.1998046785593033,-0.1721549183130264,-0.1470381766557693,-0.1290932893753052,-0.1325418800115585,-0.158482626080513,-0.1810052841901779,-0.1789300143718719,-0.161046177148819,-0.1542100310325623,-0.1591540277004242,-0.1729483902454376,-0.1787469089031219,-0.1659596562385559,-0.1450849920511246,-0.1307412981987,-0.1323282569646835,-0.1450849920511246,-0.1520737260580063,-0.1510971337556839,-0.143436998128891,-0.1362041085958481,-0.1544236540794373,-0.1807611286640167,-0.1749320924282074,-0.1529587656259537,-0.1420636624097824,-0.1546067744493484,-0.1485641002655029,-0.109714038670063,-0.09051790088415146,-0.08459731191396713,-0.08127079159021378,-0.07394634932279587,-0.06689657270908356,-0.0710776075720787,-0.07046724110841751,-0.0632343515753746,-0.05191198363900185,-0.0314035452902317,0.0007324442267417908,0.009765923023223877,0.0001525925472378731,-0.006927701644599438,-0.004089480265974998,0.03305154666304588,0.08148442208766937,0.1147190779447556,0.1463057398796082,0.1698660254478455,0.1882686913013458,0.1968443840742111,0.2028565257787704,0.2195806801319122,0.2493362277746201,0.2863246500492096,0.3066805005073547,0.2946867346763611,0.2861720621585846,0.2928251028060913,0.3061922192573547,0.3157139718532562,0.3256935477256775,0.3223059773445129,0.3118076026439667,0.299722284078598,0.286843478679657,0.2729575634002686,0.241889700293541,0.2073732763528824,0.1951048374176025,0.1971495747566223,0.1909848302602768,0.1644337326288223,0.14090396463871,0.1402935832738876,0.1572008430957794,0.1758171319961548,0.1837519407272339,0.1632435023784637,0.1167638152837753,0.08877834677696228,0.08041626960039139,0.09564501047134399,0.1184118166565895,0.1266823261976242,0.0954924151301384,0.04934842884540558,0.02188177220523357,0.03604235872626305,0.06985686719417572,0.08334604650735855,0.08236945420503616,0.09048738330602646,0.1080660447478294,0.1327555179595947,0.1531418859958649,0.1605883985757828,0.161229282617569,0.1690725386142731,0.1877193450927734,0.2164067476987839,0.2647480666637421,0.2943204939365387,0.304208517074585,0.299356073141098,0.2662740051746368,0.2178106009960175,0.2106082290410995,0.2361827492713928,0.257057398557663,0.2550126612186432,0.224280521273613,0.1843318045139313,0.1695608347654343,0.1673635095357895,0.1598254293203354,0.1689504683017731,0.186529129743576,0.1799066066741943,0.1470992118120193,0.1118198186159134,0.07205419987440109,0.05154576152563095,0.04074221104383469,0.01196325570344925,-0.01101718191057444,-0.01489303261041641,-0.00674459058791399,-0.0009765923023223877,-0.01895199529826641,-0.04016235843300819,-0.05676442757248878,-0.06997894495725632,-0.0790734589099884,-0.0795922726392746,-0.08233893662691116,-0.09289834648370743,-0.1164586320519447,-0.1470076590776443,-0.1640980243682861,-0.141056552529335,-0.079409159719944,-0.02838221378624439,-0.0004272591322660446,-0.00872829370200634,-0.04031495004892349,-0.08191168308258057,-0.09732352942228317,-0.07358012348413467,-0.03585924953222275,0.003814813680946827,0.0234382152557373,0.02661214023828506,0.03604235872626305,0.04589983820915222,0.04818872734904289,0.04919583722949028,0.07522812485694885,0.1002838239073753,0.09671315550804138,0.08233893662691116,0.06826990842819214,0.05407879874110222,0.02237006835639477,0.01083407085388899,0.01861629076302052,0.03021332435309887,0.06247138977050781,0.08490249514579773,0.0556962788105011,0.01156651508063078,-0.02587969601154327,-0.04461806267499924,-0.06140324100852013,-0.0953093022108078,-0.1264076679944992,-0.1355937421321869,-0.1275673657655716,-0.1059907823801041,-0.09201330691576004,-0.1000701934099197,-0.1268959641456604,-0.156224250793457,-0.1720633506774902,-0.1770378798246384,-0.1814325451850891,-0.2000183165073395,-0.2164983004331589,-0.2081057131290436,-0.1861018687486649,-0.1723380237817764,-0.1815240979194641,-0.1893673539161682,-0.1990112066268921,-0.2008423060178757,-0.1956541687250137,-0.189153715968132,-0.1871089786291122,-0.1909237951040268,-0.1742301732301712,-0.1576891392469406,-0.1502121090888977,-0.1372722536325455,-0.1188390776515007,-0.09863582253456116,-0.08087404817342758,-0.06750694662332535,-0.06213568523526192,-0.06253242492675781,-0.05444502085447311,-0.04257332161068916,-0.03128147125244141,-0.01452681049704552,-0.005340739153325558,0.01217688526958227,0.04525895044207573,0.0713827908039093,0.08554337918758392,0.0795922726392746,0.05478072538971901,0.04254280403256416,0.06210516765713692,0.0954008623957634,0.1154820397496223,0.1073336005210876,0.06430249661207199,0.04675435647368431,0.06942960619926453,0.1053498983383179,0.1322061866521835,0.1276589184999466,0.1026642695069313,0.08334604650735855,0.07895138114690781,0.08993804454803467,0.1241187751293182,0.1662648469209671,0.1628162413835526,0.1340678185224533,0.1098361164331436,0.1020538955926895,0.09649952501058578,0.1035493016242981,0.1319009959697723,0.1614124029874802,0.1745353490114212,0.1749931275844574,0.1849726885557175,0.1803338676691055,0.1566209942102432,0.1249122619628906,0.1045869290828705,0.1061738952994347,0.1271706223487854,0.12472914904356,0.08520767837762833,0.04083376750349998,0.01452681049704552,0.01413006987422705,-0.001953184604644775,-0.0276497695595026,-0.0313119925558567,-0.02929776906967163,-0.0320444367825985,-0.05435346439480782,-0.09207434207201004,-0.1203650012612343,-0.1302530020475388,-0.143650621175766,-0.1653187721967697,-0.1823175698518753,-0.171483501791954,-0.1800286918878555,-0.2222663015127182,-0.2881557643413544,-0.3214209377765656,-0.2807092368602753,-0.2110965251922607,-0.1802423149347305,-0.2017273455858231,-0.2614215612411499,-0.3270058333873749,-0.3628345727920532,-0.3663747012615204,-0.364909827709198,-0.3718070089817047,-0.3836176693439484,-0.395306259393692,-0.3788872957229614,-0.3396404981613159,-0.3094576895236969,-0.2981963455677032,-0.2953581213951111,-0.2687154710292816,-0.2258064448833466,-0.2004455775022507,-0.193945124745369,-0.1959288269281387,-0.1920834928750992,-0.1721244007349014,-0.1493270695209503,-0.1419110745191574,-0.1526841074228287,-0.1666310578584671,-0.1823480874300003,-0.1722464710474014,-0.1405072212219238,-0.09900204837322235,-0.06970427930355072,-0.08822900801897049,-0.123508408665657,-0.114474929869175,-0.07516708970069885,-0.05172887444496155,-0.05874812975525856,-0.07214576005935669,-0.06186101958155632,-0.04220709949731827,-0.03863643482327461,-0.0395825058221817,-0.031464584171772,-0.01199377421289682,-0.002044740132987499,0.02099673449993134,0.04257332161068916,0.02905362099409103,-0.02072206884622574,-0.05728324130177498,-0.0709250196814537,-0.08026368170976639,-0.08017212152481079,-0.05850398167967796,-0.03115939907729626,-0.03277688100934029,-0.03637806326150894,-0.04596087709069252,-0.06698812544345856,-0.07776116579771042,-0.06741538643836975,-0.04614398628473282,-0.02438428997993469,-0.007782219909131527,0.02511673420667648,0.06552323698997498,0.07431256771087646,0.05505539104342461,0.0472121350467205,0.05835139006376266,0.07196264714002609,0.1104770079255104,0.1481063216924667,0.17368084192276,0.1892147660255432,0.1972716450691223,0.1928769797086716,0.1895504593849182,0.2454603761434555,0.3211157619953156,0.3814813792705536,0.4062929153442383,0.4028443396091461,0.382335901260376,0.3449201881885529,0.3066194653511047,0.2878505885601044,0.2848292589187622,0.2712485194206238,0.2721030414104462,0.3056733906269073,0.3428144156932831,0.3582262694835663,0.3404034674167633,0.3229468762874603,0.3417157530784607,0.3786126375198364,0.3868831396102905,0.3508712947368622,0.3023774027824402,0.2839442193508148,0.2909634709358215,0.3142796158790588,0.3388775289058685,0.3362224102020264,0.2949919104576111,0.2443006634712219,0.224036380648613,0.2297433465719223,0.2257454097270966,0.186376541852951,0.1097750812768936,0.05856502056121826,0.04229865595698357,0.03390606492757797,0.02554399333894253,0.02645954862236977,0.0394909530878067,0.03433332219719887,0.01327555160969496,0.006897183135151863,0.01867732778191566,0.02325510419905186,-0.01425214391201735,-0.05163731798529625,-0.07068087160587311,-0.06390576064586639,-0.04159672930836678,-0.0399182103574276,-0.06918545812368393,-0.08633686602115631,-0.1115451529622078,-0.1424298882484436,-0.1600085496902466,-0.1642200946807861,-0.1775566935539246,-0.1791131347417831,-0.1622974276542664,-0.1662953644990921,-0.2072817236185074,-0.2483291178941727,-0.2584612667560577,-0.2468642294406891,-0.2185125350952148,-0.1769157946109772,-0.1160313710570335,-0.05880916863679886,-0.0473342090845108,-0.0632648691534996,-0.09161656349897385,-0.1242408528923988,-0.1509750634431839,-0.156346321105957,-0.1287881135940552,-0.0869472324848175,-0.07879879325628281,-0.1198767051100731,-0.1539353579282761,-0.1510360985994339,-0.1332132965326309,-0.1065401136875153,-0.06140324100852013,-0.009613330475986004,-0.002075258642435074,-0.03112887963652611,-0.06268502026796341,-0.05377361550927162,-0.01785332895815372,-0.02487258613109589,-0.06640827655792236,-0.107119970023632,-0.1419415920972824,-0.1665700227022171,-0.1380047053098679,-0.07647938281297684,-0.04638813436031342,-0.0631427988409996,-0.09994811564683914,-0.1159093007445335,-0.1019318252801895,-0.07385479658842087,-0.04992828145623207,-0.04065065458416939,-0.03854487836360931,-0.05133213475346565,-0.07348857074975967,-0.08523819595575333,-0.07394634932279587,-0.039674062281847,-0.004394665360450745,-0.0009460737928748131,-0.005096591077744961,0.007965330965816975,0.03506576642394066,0.05710013210773468,0.05645924434065819,0.04565569013357162,0.0317392498254776,0.02194280922412872,0.03329569473862648,0.06137272343039513,0.08960234373807907,0.08255256712436676,0.08081301301717758,0.08465834707021713,0.08120975643396378,0.06091494485735893,0.03674428537487984,0.03350932523608208,0.02661214023828506,0.01709036529064178,-0.007171849720180035,-0.03277688100934029,-0.03469954431056976,-0.03753776848316193,-0.05108798667788506,-0.06088442727923393,-0.06396679580211639,-0.0631427988409996,-0.08117923885583878,-0.09979552775621414,-0.1028168573975563,-0.08517716079950333,-0.06137272343039513,-0.03866695240139961,-0.004272591322660446,0.03057954646646976,0.03085421398282051,-0.01120029296725988,-0.06027405709028244,-0.04443494975566864,-0.01223792228847742,0.02322458662092686,0.0710165724158287,0.1001312285661697,0.09747611731290817,0.08462782949209213,0.1009552329778671,0.1314126998186111,0.1448408514261246,0.1386761069297791,0.1386761069297791,0.1657460182905197,0.2100588977336884,0.2529374063014984,0.2846461236476898,0.2586748898029327,0.2004150450229645,0.1921750605106354,0.2101809680461884,0.221655935049057,0.2106387466192245,0.17380291223526,0.1406598091125488,0.1388897299766541,0.1471602469682693,0.1395916640758514,0.1146885603666306,0.09042634069919586,0.07879879325628281,0.05258339270949364,0.003143406473100185,-0.03787346929311752,-0.02548295632004738,0.00872829370200634,0.03283791616559029,0.06735435128211975,0.08243049681186676,0.06900235265493393,0.04660176485776901,0.04943998530507088,0.09286782145500183,0.1377605497837067,0.1575670689344406,0.1391644030809402,0.1188390776515007,0.1279946267604828,0.1448713690042496,0.1472212970256805,0.1491134315729141,0.1766411364078522,0.2195806801319122,0.2337412685155869,0.2247077822685242,0.1945554912090302,0.1591540277004242,0.1281166970729828,0.1134067848324776,0.1225623339414597,0.1295815855264664,0.1402325481176376,0.1371196657419205,0.09637745469808578,0.05352946743369102,0.005310220643877983,-0.05825983360409737,-0.1388592123985291,-0.1845149099826813,-0.1709341704845428,-0.143559068441391,-0.1328470706939697,-0.1545152068138123,-0.1825312077999115,-0.2226935625076294,-0.2628864347934723,-0.2850123643875122,-0.299783319234848,-0.3205969333648682,-0.3488265573978424,-0.3610339760780334,-0.3588366210460663,-0.3593249320983887,-0.34778892993927,-0.3229163587093353,-0.2766807973384857,-0.2109439373016357,-0.1722464710474014,-0.1495101749897003,-0.1363872140645981,-0.1361125558614731,-0.1546067744493484,-0.173711359500885,-0.1718802452087402,-0.1474654376506805,-0.1074251532554626,-0.05917539075016975,-0.04297006130218506,-0.03674428537487984,-0.04705954343080521,-0.0556047260761261,-0.02694784477353096,0.06195257604122162,0.123599961400032,0.1051362678408623,0.05722220614552498,0.001464888453483582,-0.03878902643918991,-0.07074190676212311,-0.09384441375732422,-0.08478041738271713,-0.04150517284870148,0.001525925472378731,0.01461836602538824,0.009216589853167534,0.03042695485055447,0.07016205042600632,0.1033051535487175,0.128238782286644,0.1598864644765854,0.2098147571086884,0.2446363717317581,0.2527543008327484,0.2498245239257812,0.2582476139068604,0.2580034732818604,0.269783616065979,0.2980437576770782,0.347453236579895,0.4020508527755737,0.4445326030254364,0.4624469876289368,0.4802392721176147,0.5062105059623718,0.5479903817176819,0.5778679847717285,0.5658131837844849,0.5428327322006226,0.5520798563957214,0.5612658858299255,0.5700857639312744,0.5914792418479919,0.6222113966941833,0.6286202669143677,0.6007568836212158,0.5313882827758789,0.4468520283699036,0.3718680441379547,0.3238319158554077,0.2792748808860779,0.2294076383113861,0.161137729883194,0.08352915942668915,-0.006103701889514923,-0.07235938310623169,-0.1225012987852097,-0.1784112006425858,-0.2401806712150574,-0.3066805005073547,-0.34730064868927,-0.3708914518356323,-0.3878292143344879,-0.4206671416759491,-0.5027619004249573,-0.5975219011306763,-0.6236762404441833,-0.6183965802192688,-0.6109805703163147,-0.6128116846084595,-0.6217840909957886,-0.6285592317581177,-0.6049379110336304,-0.5647755265235901,-0.5233314037322998,-0.4895168840885162,-0.4658345282077789,-0.4345225393772125,-0.4083071351051331,-0.3887142539024353,-0.3499252200126648,-0.2932218313217163,-0.2289498597383499,-0.191320538520813,-0.1892452836036682,-0.1992553472518921,-0.2037415653467178,-0.1753898710012436,-0.1067842617630959,-0.04916531965136528,-0.02233954891562462,-0.01141392253339291,-0.01898251287639141,-0.0138248847797513,0.01867732778191566,0.05352946743369102,0.05468916893005371,0.02468947507441044,-0.002349925227463245,0.02160710468888283,0.07367168366909027,0.08304086327552795,0.08569597452878952,0.0710165724158287,0.03573717549443245,0.02652058564126492,0.0557878352701664,0.09756767749786377,0.112094484269619,0.09799493104219437,0.06888027489185333,0.04156621173024178,0.005890072323381901,-0.0002746665850281715,0.02560503035783768,0.05905331671237946,0.1001007109880447,0.1196630746126175,0.1131321117281914,0.09692678600549698,0.09955137968063354,0.1178930029273033,0.1318704783916473,0.1496017277240753,0.1447187662124634,0.1414838135242462,0.1419721096754074,0.1139866337180138,0.06237983331084251,0.02514725178480148,0.03012176975607872,0.03460799157619476,0.006317331455647945,-0.01532029174268246,-0.03506576642394066,-0.04382457956671715,-0.04812768846750259,-0.0556657612323761,-0.0794702023267746,-0.1279641091823578,-0.128635510802269,-0.09295938163995743,-0.06289865076541901,-0.03305154666304588,-0.03244117647409439,-0.04803613573312759,-0.05093539133667946,-0.02597125247120857,-0.007385479286313057,-0.0280159916728735,-0.06088442727923393,-0.07208471745252609,-0.03543198853731155,0.007171849720180035,0.02487258613109589,-0.004425183869898319,-0.05462813377380371,-0.06527908891439438,-0.0634174644947052,-0.04962309822440147,-0.03305154666304588,-0.0276497695595026,-0.07712027430534363,-0.161015659570694,-0.2362437844276428,-0.2890713214874268,-0.2925199270248413,-0.234351634979248,-0.188970610499382,-0.1984618604183197,-0.2300180047750473,-0.2586443722248077,-0.2587664425373077,-0.2607501447200775,-0.2716452479362488,-0.2666096985340118,-0.2715842127799988,-0.2804956138134003,-0.3144627213478088,-0.3803216516971588,-0.4444105327129364,-0.4897610545158386,-0.4767906665802002,-0.3846247792243958,-0.2409741580486298,-0.161198765039444,-0.1308633685112,-0.09320352971553802,-0.08578752726316452,-0.1597033590078354,-0.2223273366689682,-0.2245246767997742,-0.191228985786438,-0.1233863309025764,-0.03903317451477051,0.03393658250570297,0.0710165724158287,0.07248146086931229,0.0795922726392746,0.1122775971889496,0.1293374449014664,0.1495101749897003,0.2119510471820831,0.2768333852291107,0.3060090839862823,0.2665181457996368,0.2147587537765503,0.2251350432634354,0.2428357750177383,0.2295907437801361,0.2197943031787872,0.2006897181272507,0.1497543305158615,0.08438368141651154,0.02197332680225372,0.01077303383499384,0.03814813867211342,0.08008056879043579,0.1052583381533623,0.09640797227621078,0.06952116638422012,0.05316324532032013,0.04068117216229439,0.02911465801298618,0.05761894583702087,0.07483138889074326,0.03271584212779999,-0.05288857594132423,-0.1420331448316574,-0.145939514040947,-0.0872524157166481,-0.0552079826593399,-0.06161687150597572,-0.1331217437982559,-0.1977294236421585,-0.2175969779491425,-0.2005371302366257,-0.1784722506999969,-0.1251258850097656,-0.05398724228143692,-0.09778130799531937,-0.2264168262481689,-0.3160496950149536,-0.3407696783542633,-0.2930997610092163,-0.2212591916322708,-0.1741691380739212,-0.1783501654863358,-0.1988891214132309,-0.2014526873826981,-0.1812799423933029,-0.1934873461723328,-0.2339243739843369,-0.2106387466192245,-0.1440168470144272,-0.0791955292224884,-0.04513687640428543,-0.06216620281338692,-0.08453626930713654,-0.1024811565876007,-0.1045564115047455,-0.08203375339508057,-0.09045686572790146,-0.1079744845628738,-0.1008026376366615,-0.0953703448176384,-0.06131168454885483,-0.01434369944036007,-0.03054902888834476,-0.1496017277240753,-0.2552873194217682,-0.2733848094940186,-0.203985720872879,-0.06628620624542236,0.08365123718976974,0.04467909783124924,-0.1098055988550186,-0.1618701815605164,-0.0632038339972496,0.07760857045650482,0.1727042496204376,0.2121646851301193,0.186651200056076,0.1196630746126175,0.03366191685199738,-0.05774101987481117,-0.08618427067995071,-0.04712057858705521,3.051850944757462e-05,0.0237739197909832,0.03299050778150558,0.02996917627751827,0.01055940426886082,0.009582811966538429,-0.04519791156053543,-0.1302224844694138,-0.1590319573879242,-0.13080233335495,-0.05502487346529961,-0.03723258152604103,-0.07525864243507385,-0.1621753573417664,-0.2278817147016525,-0.2358165234327316,-0.251808226108551,-0.2810144424438477,-0.2808618545532227,-0.2574236392974854,-0.2436902970075607,-0.2424695640802383,-0.2375560849905014,-0.3084200620651245,-0.4454176425933838,-0.557542622089386,-0.5839106440544128,-0.5316629409790039,-0.4489883184432983,-0.3670766353607178,-0.3404645025730133,-0.3739738166332245,-0.4679097831249237,-0.5025787949562073,-0.4296700954437256,-0.3167515993118286,-0.2169865965843201,-0.1848811358213425,-0.2661214172840118,-0.3193456828594208,-0.3021942675113678,-0.2529679238796234,-0.221594899892807,-0.1648609936237335,-0.0632953867316246,0.07763908803462982,0.1885433495044708,0.1787163913249969,0.1039460450410843,0.05832087248563766,0.06878872215747833,0.1322367042303085,0.1718192100524902,0.1880245357751846,0.1926328390836716,0.1542100310325623,0.1674855798482895,0.2378917783498764,0.3029877543449402,0.2946867346763611,0.2379222959280014,0.2446058541536331,0.2244636416435242,0.1161534488201141,-0.02975554764270782,-0.1366618871688843,-0.1788079440593719,-0.1951353549957275,-0.1688283979892731,-0.06439405679702759,0.02502517774701118,0.04968413338065147,0.04184087738394737,0.06469924002885818,0.1726126968860626,0.3031403422355652,0.3710135221481323,0.3745536804199219,0.3152256906032562,0.2122562378644943,0.1000701934099197,0.02539139986038208,0.06457716971635818,0.2015442401170731,0.3149815499782562,0.3874019682407379,0.3687856793403625,0.2984099984169006,0.2616657018661499,0.281838446855545,0.2587664425373077,0.2004760950803757,0.1689199507236481,0.2056642323732376,0.2222357839345932,0.2279732674360275,0.1629383265972137,0.0240485854446888,-0.08093509078025818,-0.05838190764188766,0.01174962613731623,0.02975554764270782,0.04422131925821304,-0.005401776172220707,-0.1183202639222145,-0.1810052841901779,-0.1640980243682861,-0.1316568553447723,-0.1527451425790787,-0.1116977483034134,-0.08807642012834549,-0.1183202639222145,-0.146092101931572,-0.160985141992569,-0.1783806830644608,-0.1999572813510895,-0.1454512178897858,-0.08163700997829437,-0.02954191714525223,0.0009155552834272385,0.02649006620049477,0.05380413308739662,0.0477004311978817,0.08819849044084549,0.1511276662349701,0.2276375591754913,0.3252967894077301,0.4155400395393372,0.4856715500354767,0.491073340177536,0.4794152677059174,0.4763329029083252,0.5146030783653259,0.573656439781189,0.5421003103256226,0.4451735019683838,0.3497115969657898,0.287209689617157,0.287118136882782,0.3133640587329865,0.3520309925079346,0.3456831574440002,0.3075350224971771,0.2660603523254395,0.2151860147714615,0.14120914041996,0.05026398599147797,0.007507553324103355,-0.0157170332968235,-0.01928769797086716,-0.04309213533997536,-0.07553330808877945,-0.1343119591474533,-0.1776482462882996,-0.1787774264812469,-0.171147808432579,-0.1923886835575104,-0.2244026064872742,-0.2073122411966324,-0.1910763829946518,-0.2129581570625305,-0.2494277805089951,-0.2653279304504395,-0.2656636238098145,-0.2745445072650909,-0.269142746925354,-0.2479628920555115,-0.2047181576490402,-0.1517075151205063,-0.1098055988550186,-0.1066316738724709,-0.1250953674316406,-0.1537522524595261,-0.223944827914238,-0.2862941324710846,-0.2975859940052032,-0.2557145953178406,-0.1843012720346451,-0.1266518086194992,-0.06506546586751938,-0.01080355234444141,0.01077303383499384,0.01290932949632406,0.03012176975607872,0.04904324561357498,0.05679494515061378,0.05395672470331192,0.03741569444537163,0.05008087307214737,0.1192358136177063,0.1629688441753387,0.1487167030572891,0.1430707722902298,0.1574144661426544,0.1672414392232895,0.1203955188393593,0.09134189784526825,0.1240272223949432,0.1656544655561447,0.2185735702514648,0.2575762271881104,0.2498550415039062,0.2237006723880768,0.2008728235960007,0.1916867643594742,0.236976221203804,0.365245521068573,0.5144810080528259,0.5910214781761169,0.6047242879867554,0.5816828012466431,0.5671254396438599,0.5471053123474121,0.5299233794212341,0.52146977186203,0.4925992488861084,0.4554582238197327,0.413495272397995,0.3437299728393555,0.2625812590122223,0.2297128140926361,0.2354197800159454,0.2597430348396301,0.2201605290174484,0.1054719686508179,0.0199591051787138,-0.005340739153325558,-0.01931821741163731,-0.05340739339590073,-0.08783227205276489,-0.06421094387769699,-0.04919583722949028,-0.04971465095877647,-0.08584856986999512,-0.1154820397496223,-0.08914456516504288,-0.02279732748866081,-0.04321420937776566,-0.1636707633733749,-0.2590716183185577,-0.2650227248668671,-0.2708822786808014,-0.2756431698799133,-0.2677388787269592,-0.1882992088794708,-0.1397442519664764,-0.1717581748962402,-0.2121036350727081,-0.2155217081308365,-0.1968138664960861,-0.1666005402803421,-0.1045869290828705,-0.06103701889514923,-0.1016571521759033,-0.1297952234745026,-0.161290317773819,-0.2036194950342178,-0.2120120823383331,-0.1804559528827667,-0.1799066066741943,-0.2220831960439682,-0.2630695402622223,-0.2386547476053238,-0.0949430838227272,-0.007690664380788803,-0.02710043638944626,-0.1098971515893936,-0.1982177197933197,-0.2545548975467682,-0.3097628653049469,-0.317789226770401,-0.2762840688228607,-0.2155522257089615,-0.1973631978034973,-0.241889700293541,-0.2614215612411499,-0.2804040610790253,-0.2891018390655518,-0.2601397633552551,-0.1826532781124115,-0.06167790666222572,0.04425184056162834,0.07431256771087646,0.05078279972076416,0.007324442267417908,0.002685628831386566,0.08932767808437347,0.2032532691955566,0.251808226108551,0.2913907170295715,0.3508712947368622,0.4287240207195282,0.4194769263267517,0.3415326476097107,0.2598040699958801,0.1746269166469574,0.158665731549263,0.2582781314849854,0.3905148506164551,0.4595172107219696,0.4318063855171204,0.3638111650943756,0.2943204939365387,0.2203436344861984,0.171361431479454,0.1004669368267059,0.01330607011914253,-0.06512650102376938,-0.08813745528459549,-0.07477034628391266,-0.08291879296302795,-0.109714038670063,-0.1160924136638641,-0.07342753559350967,-0.1043427810072899,-0.2296517789363861,-0.2430494129657745,-0.2467726618051529,-0.1808221638202667,-0.1595202535390854,-0.1646473556756973,-0.112002931535244,-0.1252479702234268,-0.2060914933681488,-0.2625812590122223,-0.2681966722011566,-0.2310556322336197,-0.1204870790243149,0.003997924737632275,0.1368755102157593,0.3120517730712891,0.4600970447063446,0.4567705392837524,0.4189275801181793,0.3974730670452118,0.3994872868061066,0.4265572130680084,0.4917142391204834,0.5336466431617737,0.5442671179771423,0.5153355598449707,0.443769633769989,0.3888363242149353,0.4225898087024689,0.4716025292873383,0.4904324412345886,0.5542771816253662,0.669759213924408,0.6572466492652893,0.447798103094101,0.2512588798999786,0.1958983093500137,0.2487258464097977,0.1871700137853622,-0.00555436871945858,-0.0555436871945858,-0.05734428018331528,-0.01339762564748526,0.03598132357001305,0.01715140230953693,-0.06094546243548393,-0.06283760815858841,-0.06476027518510818,-0.06668294221162796,-0.06866664439439774,-0.0711386427283287,-0.07367168366909027,-0.07574693858623505,-0.07782220095396042,-0.07992797344923019,-0.08258308470249176,-0.08529923111200333,-0.0874965637922287,-0.08972442150115967,-0.09198278933763504,-0.09424115717411041,-0.09710989892482758,-0.1000396758317947,-0.1024201214313507,-0.1048005595803261,-0.107211522758007,-0.109653003513813,-0.1127658933401108,-0.1159093007445335,-0.1184423342347145,-0.1210058927536011,-0.123599961400032,-0.1268654465675354,-0.1301919668912888,-0.1328775882720947,-0.1355937421321869,-0.1383403986692429,-0.141117587685585,-0.1446272134780884,-0.1256141811609268,-0.05310220643877983,-0.002288888208568096,0.01651051454246044,0.004272591322660446,-0.01559495832771063,-0.05438398569822311,-0.0951872318983078,-0.05429242923855782,0.0471816174685955,0.1629688441753387,0.3283181190490723,0.4627826809883118,0.5283364653587341,0.5072786808013916,0.4335764646530151,0.4067201614379883,0.4164250493049622,0.4186529219150543,0.4152348339557648,0.4251228272914886,0.5095980763435364,0.6197393536567688,0.7061067819595337,0.6988738775253296,0.6147648692131042,0.5128635764122009,0.3379924893379211,0.241737112402916,0.2470168173313141,0.2781762182712555,0.3155613839626312,0.335398405790329,0.3758659660816193,0.4774926006793976,0.5494857430458069,0.5511032342910767,0.5502182245254517,0.4978484511375427,0.3728141188621521,0.2376476377248764,0.09411908686161041,0.0718100517988205,0.07052827626466751,0.06884975731372833,0.06927701830863953,0.06576738506555557,0.08539079129695892,0.204168826341629,0.3023774027824402,0.3034760653972626,0.2052369713783264,0.1292458921670914,0.1481673568487167,0.1903134286403656,0.2170476466417313,0.2950834631919861,0.3334147036075592,0.2716757655143738,0.1648915112018585,0.08868678659200668,0.08990752696990967,0.1594897359609604,0.1052278205752373,0.07538072019815445,0.07348857074975967,0.0715353861451149,0.1166417449712753,0.1675771325826645,0.189092680811882,0.2363353371620178,0.2705160677433014,0.221503347158432,0.1440168470144272,0.07208471745252609,0.06769005209207535,0.07483138889074326,0.1467635184526443,0.2018799334764481,0.143650621175766,0.06118961051106453,0.05856502056121826,0.0791955292224884,0.1815240979194641,0.241462454199791,0.2115237861871719,0.1455427706241608,0.1138645559549332,0.09375286102294922,0.1438337415456772,0.1226233690977097,0.04522843286395073,0.04205450788140297,0.03878902643918991,0.03546250984072685,0.03118991665542126,0.02682577073574066,0.1178930029273033,0.2729880809783936,0.3081148862838745,0.2458876371383667,0.07254249602556229,0.0199285876005888,0.01605273596942425,0.01208532974123955,0.008056886494159698,0.002899258397519588,-0.002349925227463245,-0.006653035059571266,-0.01104770042002201,-0.0155034027993679,-0.0200506616383791,-0.02587969601154327,-0.0318002887070179,0.04379406198859215,0.1813104599714279,0.1857356429100037,0.2044740170240402,0.2011780142784119,0.07690664380788803,-0.0316476933658123,-0.05121006071567535,-0.05655079707503319,-0.0633869469165802,-0.07034516334533691,-0.07599108666181564,-0.08175908774137497,-0.0876186415553093,0.02432325296103954,0.09430219233036041,0.03012176975607872,0.07473982870578766,0.1565599590539932,0.2050538659095764,0.1686452776193619,0.1506698876619339,0.2136295735836029,0.3207800388336182,0.2833948731422424,0.2420728206634521,0.1928159445524216,0.2542191743850708,0.4419995844364166,0.634113609790802,0.7781914472579956,0.8480178117752075,0.9440595507621765,0.9375286102294922,0.6938077807426453,0.4210943877696991,0.2290108948945999,0.05838190764188766,-0.03787346929311752,-0.04342783987522125,0.2226020097732544,0.5288552641868591,0.4599749743938446,0.03277688100934029,-0.06695760786533356,0.08084353059530258,0.06775109469890594,-0.08383434265851974,-0.09152501076459885,-0.1013519689440727,-0.1113315224647522,-0.1194799616932869,-0.1277504861354828,-0.1361735910177231,-0.1468855887651443,-0.1577806919813156,-0.1666920930147171,-0.1756950616836548,-0.1848506182432175,-0.1941587626934052,-0.2059999406337738,-0.2180242389440536,-0.2278206795454025,-0.2377697080373764,-0.07800531387329102,0.09726248681545258,-0.04681539535522461,-0.1961424648761749,0.334482878446579,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.41261026263237,-0.1877803951501846,-0.1980040967464447,-0.2083803862333298,-0.2189397811889648,-0.2179631888866425,-0.2199774235486984,-0.08072146028280258,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.9440595507621765,0.522415816783905,-0.1273842602968216,-0.1379741877317429,-0.1514328420162201,-0.1651661694049835,-0.176366463303566,-0.1877193450927734,-0.1992858648300171,-0.2110049724578857,-0.2053590565919876,-0.1398968547582626,0.1162144839763641,0.1886959373950958,-0.0791344940662384,-0.1598254293203354,-0.1906186044216156,-0.2986846566200256,-0.3120517730712891,-0.3256324827671051,-0.3394268751144409,-0.23917356133461,-0.1629688441753387,0.1956541687250137,0.4932706654071808,0.538285493850708,0.3180333971977234,-0.013702810741961,-0.2662129700183868,-0.3242286443710327,-0.3814508616924286,-0.3553270101547241,-0.365672767162323,-0.4687337875366211,-0.4892422258853912,-0.5056917071342468,-0.52238529920578,-0.539262056350708,-0.3979003131389618,0.04998932033777237,0.2125919312238693,-0.06530961394309998,-0.4178289175033569,-0.6099429130554199,-0.5553758144378662,-0.01678518019616604,0.5199133157730103,0.616718053817749,0.1873226165771484,-0.2673726677894592,-0.6248970031738281,-0.6925565600395203,-0.712057888507843,-0.7318338751792908,-0.7518540024757385,-0.52092045545578,-0.2361827492713928,0.04828028380870819,0.1809137314558029,0.2108523845672607,0.4245735108852386,0.8665730953216553,0.9440595507621765,0.9440595507621765,0.8099612593650818,0.08270516246557236,-0.5866267681121826,-0.7930539846420288,-0.8145695328712463,-0.8362987041473389,-0.8583330512046814,-0.8341013789176941,-0.6014893054962158,-0.4118167757987976,-0.02758873254060745,0.5507065057754517,0.905117928981781,0.9348430037498474,-0.08304086327552795,-0.8277230262756348,0.478072464466095,0.7994323372840881,-0.4846339225769043,-0.9440900683403015,-0.9119541049003601,-0.7100436687469482,-0.5902279615402222,-0.6611530184745789,-0.8849452137947083,-0.9230323433876038,-0.7717825770378113,-0.4463026821613312,-0.2338023036718369,-0.1508529931306839,0.1582995057106018,-0.2905972599983215,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9280983805656433,-0.903622567653656,-0.9440900683403015,-0.9440900683403015,-0.4874416291713715,-0.2165288180112839,-0.4662922918796539,-0.8009277582168579,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.8985564708709717,-0.7278664708137512,-0.6426587700843811,-0.5899838209152222,-0.5789971351623535,-0.4694357216358185,-0.3131504356861115,-0.1878414303064346,-0.03588976711034775,0.05154576152563095,0.05377361550927162,0.0555742047727108,0.05740531533956528,-0.06961271911859512,-0.1402935832738876,-0.1432843953371048,-0.1452986299991608,-0.1480758041143417,-0.1178930029273033,-0.01474044006317854,0.04992828145623207,0.05224768817424774,0.04367198795080185,-0.0314035452902317,-0.113284707069397,-0.1333353668451309,-0.1036103367805481,-0.07065034657716751,0.02002014219760895,0.05349894613027573,0.0554826520383358,0.05749687179923058,0.06002990901470184,0.06262398511171341,0.06472975760698318,0.06686605513095856,0.06900235265493393,0.0711996853351593,0.07397686690092087,0.03469954431056976,-0.0472121350467205,-0.1053193733096123,-0.1099581867456436,-0.110934779047966,-0.111941896378994,-0.1126743406057358,-0.1134678199887276,-0.1142307817935944,-0.1150242611765862,-0.1159398183226585,-0.1168553754687309,-0.1175878196954727,-0.1183202639222145,-0.1190527081489563,-0.1197546347975731,-0.1206701844930649,-0.1215552240610123,-0.1222571507096291,-0.1229285597801208,-0.123599961400032,-0.1244239658117294,-0.1252174377441406,-0.125827819108963,-0.1264992207288742,-0.1270790696144104,-0.1276894509792328,-0.128513440489769,-0.1292458921670914,-0.1297647058963776,-0.1303750723600388,-0.130893886089325,-0.1314432173967361,-0.1321146339178085,-0.1327250003814697,-0.1332132965326309,-0.1336710751056671,-0.1341898888349533,-0.1347392201423645,-0.1352580338716507,-0.1356547772884369,-0.1360820382833481,-0.1364482492208481,-0.1368449926376343,-0.1372417360544205,-0.1376689970493317,-0.1379741877317429,-0.1382488459348679,-0.1384930014610291,-0.1387371420860291,-0.1390118151903152,-0.1392254382371902,-0.1394085586071014,-0.1396221816539764,-0.1396832168102264,-0.1398663222789764,-0.1399578899145126,-0.1400494426488876,-0.1400189250707626,-0.1400494426488876,-0.1400189250707626,-0.1399578899145126,-0.1398663222789764,-0.1397137343883514,-0.1395916640758514,-0.1394085586071014,-0.1392559558153152,-0.1389202624559402,-0.1386455893516541,-0.1383098810911179,-0.1380352228879929,-0.1376384794712067,-0.1371807008981705,-0.1366618871688843,-0.1362041085958481,-0.1356852948665619,-0.1351359635591507,-0.1345866322517395,-0.1338846981525421,-0.1330301761627197,-0.1323587745428085,-0.1316568553447723,-0.130893886089325,-0.1298867762088776,-0.1288186311721802,-0.1279641091823578,-0.1270485520362854,-0.126071959733963,-0.1251564025878906,-0.1238135918974876,-0.1224402636289597,-0.1213110759854317,-0.1201208531856537,-0.1188390776515007,-0.1176183372735977,-0.1159093007445335,-0.1142002642154694,-0.1127658933401108,-0.1112704873085022,-0.1097445636987686,-0.1077608540654182,-0.1057161167263985,-0.1040375977754593,-0.1022370085120201,-0.1004364117980003,-0.09866634011268616,-0.09628589451313019,-0.09384441375732422,-0.09179967641830444,-0.08972442150115967,-0.0875576063990593,-0.08539079129695892,-0.08255256712436676,-0.0796227902173996,-0.07727286964654922,-0.07477034628391266,-0.07232886552810669,-0.06900235265493393,-0.06567583233118057,-0.06277657300233841,-0.05957213044166565,-0.05508590862154961,-0.04675435647368431,0.08838160336017609,-0.1238135918974876,-0.7233802080154419,-0.9440900683403015,-0.9440900683403015,-0.9440900683403015,-0.005432294681668282,0.02081362344324589,0.02572710439562798,0.03070162050426006,0.03576769307255745,-0.04123050719499588,-0.0869472324848175,-0.08435316383838654,-0.08093509078025818,-0.07754753530025482,-0.07403790205717087,-0.06955168396234512,-0.06494338810443878,-0.06115909293293953,-0.05728324130177498,-0.05334635451436043,-0.04934842884540558,-0.04416028410196304,-0.03888058289885521,-0.03457747027277946,-0.03018280677497387,-0.02569658495485783,-0.0199591051787138,-0.0140690328553319,-0.009277626872062683,-0.004333628341555595,0.0006408886983990669,0.005737479776144028,0.01229895930737257,0.01892147585749626,0.02426221594214439,0.02981658466160297,0.03537095338106155,0.04113895073533058,0.04843287542462349,0.0558793917298317,0.06192205473780632,0.06814783066511154,0.07437361031770706,0.08239997923374176,0.09054841846227646,0.09720145165920258,0.1039765626192093,0.110843226313591,0.1178319677710533,0.1267128586769104,0.1357463300228119,0.1430707722902298,0.1505478024482727,0.1581164002418518,0.1658375859260559,0.1756340265274048,0.1856135725975037,0.193670466542244,0.2019104659557343,0.2102115005254745,0.2208014130592346,0.2316049635410309,0.2403027415275574,0.2491225898265839,0.2580645084381104,0.2670674622058868,0.2806482017040253,0.2926114797592163,0.3030487895011902,0.3079012334346771,0.2717673182487488,0.4401074349880219,0.4547868371009827,0.4622333347797394,0.4664449095726013,-0.9440900683403015,-0.8318125009536743,0.1928159445524216,0.3806878924369812,0.3718070089817047,0.382610559463501,0.3935361802577972,0.4046143889427185,0.4186224043369293,0.4328745305538177,0.4444105327129364,0.4561296403408051,0.4679403007030487,0.4829249083995819,0.4981231093406677,0.5104220509529114,0.5229346752166748,0.5355387926101685,0.5482650399208069,0.5643787980079651,0.5807672142982483,0.5940427780151367,0.6074404120445251,0.6210211515426636,0.634693443775177,0.652058482170105,0.669606626033783,0.6838587522506714,0.6981719136238098,0.712759792804718,0.730521559715271,0.748832643032074,0.7629322409629822,0.7746208310127258,0.7779167890548706,0.9016388654708862,0.2627338469028473,-0.0004272591322660446,-0.008941923268139362,-0.01278725545853376,-0.01141392253339291,-0.0101016266271472,-0.006408886983990669,-0.01333658862859011,-0.01580858789384365,-0.01809747703373432,-0.01492355111986399,-0.0008239997550845146,0.003326517529785633,0.003845332190394402,0.0009460737928748131,-0.0006714072078466415,-0.001434369944036007,0.003509628586471081,0.008545182645320892,0.007629627361893654,0.01251258887350559,0.01449629198759794,0.01275673694908619,0.01290932949632406,0.01678518019616604,0.01742606982588768,0.02072206884622574,0.02044740132987499,0.01245155185461044,0.004150517284870148,0.002105777151882648,0.009063997305929661,0.008484145626425743,0.01065095979720354,0.005767998285591602,-0.006897183135151863,-0.005859553813934326,-0.007507553324103355,-0.01135288551449776,-0.01043733023107052,-0.01077303383499384,-0.002349925227463245,-0.001861629076302052,-0.004547257907688618,-0.003357036039233208,-0.007599108852446079,-0.008911404758691788,-0.006530961021780968,-0.004119998775422573,0.001953184604644775,0.0009765923023223877,-0.002349925227463245,-0.0006103701889514923,-0.002899258397519588,-0.009643848985433578,-0.01217688526958227,-0.01229895930737257,-0.003936887718737125,0.0003051850944757462,-0.006500442512333393,-0.01397747732698917,-0.01342814415693283,-0.003234962001442909,-0.002685628831386566,-0.005645924247801304,-0.006103701889514923,-0.0006103701889514923,0.007202368229627609,0.00476088747382164,0.002746665850281715,0.002868739888072014,0.0001831110566854477,0.001953184604644775,0.004669331945478916,0.003662221133708954,0.002624591812491417,0.002410962246358395,0.001068147830665112,0.004669331945478916,0.009063997305929661,0.01797540299594402,0.0202032532542944,0.01760918088257313,0.0140690328553319,0.007904293946921825,-3.051850944757462e-05,0.001922666095197201,-0.002807702869176865,-0.003326517529785633,-0.0006714072078466415,-0.003997924737632275,-0.002929776906967163,-0.0006103701889514923,0.001678518019616604,-9.155552834272385e-05,-0.0101016266271472,-0.01220740377902985,-0.006195257417857647,-0.004638813436031342,0.001800592057406902,-0.0007324442267417908,-0.0003357036039233208,0.002899258397519588,-0.007477034814655781,-0.01293984800577164,-0.01431318093091249,-0.01272621843963861,-0.006073183380067348,0.0039674062281847,0.004181035794317722,0.002166814170777798,0.006683553569018841,0.005096591077744961,-0.0005493331700563431,0.0005188146606087685,0.006897183135151863,0.01062044128775597,0.0140690328553319,0.01922666095197201,0.02032532729208469,0.0161137729883194,0.01229895930737257,0.01040681172162294,0.01013214513659477,0.01498458813875914,0.013702810741961,0.01284829247742891,0.008575701154768467,0.0004577776417136192,0.001495406962931156,0.003875850699841976,0.0003662221133708954,9.155552834272385e-05,-0.0008850367739796638,-0.0004272591322660446,-0.0009155552834272385,-0.0001220740377902985,-0.00238044373691082,-0.005005035549402237,-0.0090]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>astra_xcorr_ts_ff</key>
<param><key>id</key><value>astra_xcorr_ts_ff_0</value></param>
<param><key>ip_address</key><value>10.0.5.57</value></param>
<param><key>center_mic_offset</key><value>center_mic_offset</value></param>
<param><key>node_number</key><value>1</value></param>
<param><key>port_num</key><value>5556</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_window</key><value>5000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>baretta_9mm</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[-0.2771385908126831,-0.2144535630941391,-0.1200598180294037,-0.04434339329600334,0.008819849230349064,0.0400708019733429,0.06903287023305893,0.0950956791639328,0.1161534488201141,0.1406903266906738,0.1313211470842361,0.09906308352947235,0.04202398657798767,-0.01507614366710186,-0.01150547806173563,0.03006073273718357,0.03585924953222275,0.01541184727102518,0.002929776906967163,-0.03595080599188805,-0.08398693799972534,-0.1391338855028152,-0.1523178815841675,-0.1103244125843048,-0.07245094329118729,-0.02237006835639477,0.0120242927223444,0.0241401419043541,0.03756828606128693,0.08841212093830109,0.1792352050542831,0.2511062920093536,0.2906888127326965,0.287301242351532,0.2655720710754395,0.2775048017501831,0.3021637499332428,0.3122959136962891,0.3141575455665588,0.2901089489459991,0.2501296997070312,0.2036194950342178,0.1293069273233414,0.06176946312189102,0.02233954891562462,0.002410962246358395,0.03744621202349663,0.1075167059898376,0.1448408514261246,0.1606189161539078,0.1678212881088257,0.1526230722665787,0.1360515207052231,0.1114841178059578,0.07583849877119064,0.05395672470331192,0.05810724198818207,0.07580798119306564,0.09567552804946899,0.1119113713502884,0.1006500422954559,0.06976531445980072,0.04217658191919327,0.03836176544427872,0.06118961051106453,0.09250160306692123,0.1256752163171768,0.1590929925441742,0.1812189072370529,0.1818597912788391,0.2037110477685928,0.2396618574857712,0.2463148832321167,0.2557145953178406,0.2244331240653992,0.1617175787687302,0.1426129937171936,0.1105380430817604,0.03677480295300484,-0.01892147585749626,-0.07040619850158691,-0.1251869201660156,-0.1424909234046936,-0.1752067655324936,-0.2229072004556656,-0.256996363401413,-0.2668843567371368,-0.2717368006706238,-0.2902310192584991,-0.2729880809783936,-0.2656331062316895,-0.2877590358257294,-0.2681051194667816,-0.2259285300970078,-0.2463454157114029,-0.2815637588500977,-0.2904141247272491,-0.2920926511287689,-0.2706686556339264,-0.2659382820129395,-0.2687765061855316,-0.2397228926420212,-0.1631214320659637,-0.09964293241500854,-0.09826960414648056,-0.08893093466758728,-0.03582873195409775,0.04690694808959961,0.1212805584073067,0.1634266227483749,0.1884823143482208,0.2320017069578171,0.2482375502586365,0.1649830639362335,0.05206457898020744,-0.0319833979010582,-0.0635395348072052,-0.08590960502624512,-0.1597033590078354,-0.204321414232254,-0.2030701637268066,-0.1710257232189178,-0.109561450779438,-0.0474562831223011,0.00436414685100317,0.007690664380788803,0.003448591567575932,0.0006103701889514923,-0.03540147095918655,-0.03665272891521454,-0.04907376319169998,-0.09659108519554138,-0.1470992118120193,-0.1962645351886749,-0.1423383355140686,-0.02136295661330223,0.08780175447463989,0.1667226105928421,0.1464888453483582,0.03106784261763096,-0.06588946282863617,-0.07882931083440781,-0.01818903163075447,0.04852443188428879,0.07190161198377609,0.0871913805603981,0.1023590788245201,0.1499679535627365,0.2023987621068954,0.2307199388742447,0.237006738781929,0.2124698609113693,0.219153419137001,0.241584524512291,0.2550126612186432,0.2475051134824753,0.2046876400709152,0.1978209763765335,0.219122901558876,0.2533341348171234,0.304330587387085,0.2680440545082092,0.1909543126821518,0.2022461593151093,0.2371593415737152,0.2175664603710175,0.193609431385994,0.1554612815380096,0.06424146145582199,-0.01467940304428339,-0.04544205963611603,-0.08105716109275818,-0.1658986210823059,-0.2616351842880249,-0.2916043698787689,-0.2679525017738342,-0.2434156388044357,-0.2331003695726395,-0.2380138486623764,-0.2197332680225372,-0.191442608833313,-0.1746879518032074,-0.161320835351944,-0.1812189072370529,-0.1985534280538559,-0.204290896654129,-0.2468337118625641,-0.2759483754634857,-0.2363658547401428,-0.1529587656259537,-0.1028168573975563,-0.08294931054115295,-0.0241401419043541,0.04565569013357162,0.08224738389253616,0.1100802645087242,0.1271401047706604,0.08142338693141937,0.04013184085488319,0.07718130946159363,0.1349223256111145,0.1801812797784805,0.2199774235486984,0.2338023036718369,0.2274849712848663,0.2299569696187973,0.2288277894258499,0.2161626070737839,0.1941892802715302,0.1630909144878387,0.158879354596138,0.1748100221157074,0.1868038028478622,0.2016052752733231,0.1945860236883163,0.1631519496440887,0.1098971515893936,0.05371257662773132,0.005188146606087685,-0.03808709979057312,-0.079256571829319,-0.1394695937633514,-0.1875362396240234,-0.2037110477685928,-0.2082277834415436,-0.2116458564996719,-0.2125003784894943,-0.2461317777633667,-0.2513809502124786,-0.1754509061574936,-0.1249122619628906,-0.1438337415456772,-0.1833246797323227,-0.1798760890960693,-0.1386455893516541,-0.1022370085120201,-0.08975493907928467,-0.06442457437515259,0.004455702379345894,0.04977568984031677,0.04119998961687088,0.03833124786615372,0.07016205042600632,0.1068453043699265,0.13104647397995,0.1268349289894104,0.1086153760552406,0.06918545812368393,0.04101687669754028,0.03750724717974663,-0.002685628831386566,-0.006866664625704288,-0.00912503432482481,-0.0317087322473526,0.01760918088257313,0.04367198795080185,0.009247108362615108,-0.02780236303806305,-0.03891110047698021,0.003265480510890484,0.05746635422110558,0.06894131004810333,0.07202368229627609,0.1059602648019791,0.1267128586769104,0.09115878492593765,0.04467909783124924,0.02649006620049477,-0.01287881098687649,-0.031525619328022,-0.0397961363196373,-0.05029450356960297,-0.01928769797086716,-0.02935880608856678,-0.05435346439480782,-0.08801538497209549,-0.1553086936473846,-0.1963866055011749,-0.2396008223295212,-0.2286751866340637,-0.1155430749058723,-0.03219702839851379,-0.03628650680184364,-0.07440412789583206,-0.08114871382713318,-0.05035554245114326,-0.02691732533276081,-0.03839228674769402,-0.07889034599065781,-0.1039765626192093,-0.07370220124721527,-0.02447584457695484,-0.03762932121753693,-0.01565599627792835,0.007110812701284885,-0.08093509078025818,-0.1679738759994507,-0.2474135607481003,-0.252357542514801,-0.1658986210823059,-0.0949125662446022,-0.03238013759255409,0.01217688526958227,0.05920590832829475,0.1337321102619171,0.1571398079395294,0.1196935921907425,0.1264992207288742,0.161259800195694,0.1806695759296417,0.1817987561225891,0.1653187721967697,0.1617786139249802,0.1357158124446869,0.07061982899904251,0.02938932552933693,0.01989806815981865,-0.01004058960825205,-0.05713064968585968,-0.09598071128129959,-0.1186254471540451,-0.1251869201660156,-0.1163670793175697,-0.1105380430817604,-0.1153599694371223,-0.09768974781036377,-0.05847346410155296,-0.03823969140648842,-0.03830073028802872,-0.01730399578809738,0.01940977200865746,0.06259346008300781,0.1023285612463951,0.14090396463871,0.1775566935539246,0.1733451336622238,0.1571703255176544,0.141300693154335,0.1342509239912033,0.1384624838829041,0.1193578913807869,0.09729301184415817,0.04672383889555931,-0.04010132327675819,-0.09305093437433243,-0.0949430838227272,-0.06610309332609177,-0.02240058593451977,0.04898220673203468,0.109500415623188,0.1186864823102951,0.1200598180294037,0.1019928604364395,0.07074190676212311,0.07583849877119064,0.09823907911777496,0.09021271765232086,0.03039643540978432,-0.04162724688649178,-0.0716269388794899,-0.06115909293293953,0.006500442512333393,0.02563554793596268,-0.07983642071485519,-0.1590014398097992,-0.1927243918180466,-0.2031006813049316,-0.2008117884397507,-0.2095706015825272,-0.1706289798021317,-0.1166722625494003,-0.07821893692016602,-0.01702932827174664,0.04931791126728058,0.05883968621492386,0.04199346899986267,0.0715048685669899,0.1113315224647522,0.1117893010377884,0.09997864067554474,0.1304361075162888,0.171361431479454,0.1874752044677734,0.2062135636806488,0.2246162295341492,0.234534740447998,0.2471388876438141,0.2533951699733734,0.2659993171691895,0.2957548797130585,0.3023468852043152,0.2972502708435059,0.2677388787269592,0.2032837867736816,0.126163512468338,0.06305123865604401,0.03659169375896454,0.0198370311409235,0.02185125276446342,0.001556443981826305,-0.06735435128211975,-0.09967344999313354,-0.0953398272395134,-0.143498033285141,-0.234595775604248,-0.2947477698326111,-0.2884609401226044,-0.2334360778331757,-0.1859492808580399,-0.1791741698980331,-0.2033753544092178,-0.2212897092103958,-0.2288583070039749,-0.2022766768932343,-0.1595202535390854,-0.130649745464325,-0.06851405650377274,-0.02935880608856678,-0.03451643511652946,-0.06982634961605072,-0.1031220406293869,-0.08984649181365967,-0.1007416024804115,-0.09665212035179138,-0.03103732503950596,0.1015350818634033,0.2062440812587738,0.2093874961137772,0.2358470410108566,0.2254707515239716,0.1377605497837067,0.0796227902173996,0.1451155096292496,0.2504348754882812,0.2670674622058868,0.3061311542987823,0.2982878983020782,0.1944334208965302,0.113254189491272,0.01669362559914589,-0.02270577102899551,0.07837153226137161,0.1567430645227432,0.1040375977754593,0.005035554058849812,-0.0317392498254776,-0.01055940426886082,0.005462813191115856,-0.005066072568297386,-0.02853480726480484,-0.04318369179964066,-0.04617450386285782,-0.04278695210814476,-0.02853480726480484,-0.02807702869176865,-0.06057924032211304,-0.06640827655792236,-0.07275612652301788,-0.09765923023223877,-0.1232032254338264,-0.1626636534929276,-0.1694082468748093,-0.1527451425790787,-0.1116061881184578,-0.04623554274439812,0.03433332219719887,0.09662160277366638,0.1098055988550186,0.09009063988924026,0.0718710869550705,0.05209509655833244,-0.01001007109880447,-0.03411969542503357,-0.04376354441046715,-0.1280556619167328,-0.236854150891304,-0.287148654460907,-0.2880947291851044,-0.2839442193508148,-0.281899482011795,-0.2797937095165253,-0.3015533983707428,-0.3354594707489014,-0.2960600554943085,-0.2592852711677551,-0.2641071677207947,-0.2514114677906036,-0.2293771207332611,-0.1758476495742798,-0.126102477312088,-0.1663258820772171,-0.2480849623680115,-0.287575900554657,-0.3057649433612823,-0.3084505796432495,-0.2624591886997223,-0.1497238129377365,-0.05035554245114326,-0.005340739153325558,0.03125095367431641,0.03625598922371864,0.05856502056121826,0.1594592183828354,0.2162541598081589,0.1995300203561783,0.176335945725441,0.1590014398097992,0.1447187662124634,0.1243018880486488,0.1289712190628052,0.1124912276864052,0.08914456516504288,0.06073183566331863,0.0315561406314373,0.02633747458457947,-0.03805658221244812,-0.09662160277366638,-0.1163060367107391,-0.1104770079255104,-0.06848353892564774,-0.06393627822399139,-0.1196325570344925,-0.1710257232189178,-0.1427350640296936,-0.11444441229105,-0.1756645441055298,-0.2148503065109253,-0.1659291386604309,-0.08789330720901489,-0.01174962613731623,0.05438398569822311,0.09363079071044922,0.1062349304556847,0.1371501833200455,0.1819513589143753,0.2176274955272675,0.23911252617836,0.2377697080373764,0.2186346054077148,0.1592150628566742,0.1157567054033279,0.1122470796108246,0.1094393730163574,0.145939514040947,0.1839960962533951,0.1571092903614044,0.1221655905246735,0.1102938950061798,0.1069368571043015,0.0954008623957634,0.08124027401208878,0.0869472324848175,0.08883938193321228,0.08246101438999176,0.02694784477353096,-0.02548295632004738,-0.0005188146606087685,0.0472731702029705,0.09704886376857758,0.1138645559549332,0.1007721200585365,0.1105075255036354,0.1365398168563843,0.1734672039747238,0.2013000845909119,0.2026123851537704,0.1790520995855331,0.1353495866060257,0.108401745557785,0.08987700939178467,0.0554521307349205,-0.02270577102899551,-0.1000396758317947,-0.146122619509697,-0.1791436523199081,-0.176183357834816,-0.1680043935775757,-0.1255531460046768,-0.05319376289844513,0.008880886249244213,0.04644917324185371,0.03573717549443245,0.03311258181929588,0.03765984252095222,0.04165776446461678,0.112155519425869,0.1879940181970596,0.1927854269742966,0.1774346083402634,0.1606799513101578,0.1450544744729996,0.1401409953832626,0.1217993721365929,0.08563493937253952,0.0319833979010582,-0.03830073028802872,-0.1045564115047455,-0.1514328420162201,-0.1772820204496384,-0.1947386115789413,-0.2082277834415436,-0.2156743109226227,-0.2411877810955048,-0.2751548886299133,-0.30448317527771,-0.3212988674640656,-0.3310037553310394,-0.3255104124546051,-0.2928251028060913,-0.2881557643413544,-0.3014923632144928,-0.3264564871788025,-0.3320413827896118,-0.286904513835907,-0.2442701458930969,-0.1345561146736145,0.01669362559914589,0.07757805287837982,0.09347819536924362,0.1046784892678261,0.09686575084924698,0.07791375368833542,0.07028412818908691,0.0870082676410675,0.1255836635828018,0.1649525463581085,0.1775872111320496,0.1760002374649048,0.1775872111320496,0.1927243918180466,0.1846369802951813,0.1527146250009537,0.1194494441151619,0.1115451529622078,0.1452986299991608,0.1902523934841156,0.23941770195961,0.2594073414802551,0.2468031793832779,0.2255623042583466,0.2105166763067245,0.186559647321701,0.1565294414758682,0.1791741698980331,0.1916867643594742,0.1338236629962921,0.05911435186862946,-0.03238013759255409,-0.1366008520126343,-0.2119205296039581,-0.2447889596223831,-0.2467726618051529,-0.2351756393909454,-0.2219306081533432,-0.2145451158285141,-0.2124698609113693,-0.2200079411268234,-0.2188482284545898,-0.2003540098667145,-0.1807000935077667,-0.1752983182668686,-0.194036677479744,-0.1949827522039413,-0.1648915112018585,-0.0953703448176384,-0.001678518019616604,0.01712088473141193,-0.01162755209952593,0.02273629046976566,0.1024811565876007,0.1233863309025764,0.1508529931306839,0.1924192011356354,0.1964476406574249,0.204107791185379,0.2102420181035995,0.2603534162044525,0.2962431609630585,0.2893154621124268,0.2708212435245514,0.2900173962116241,0.3033539950847626,0.2677999138832092,0.2636188864707947,0.2202825993299484,0.1896725296974182,0.2006897181272507,0.1636402457952499,0.1000701934099197,0.02447584457695484,-0.06949064880609512,-0.1631214320659637,-0.2030091285705566,-0.2038026005029678,-0.221869558095932,-0.2497024387121201,-0.2638019919395447,-0.2529068887233734,-0.2231208235025406,-0.2616046667098999,-0.3634144067764282,-0.3256935477256775,-0.2077089697122574,-0.1879940181970596,-0.2122867554426193,-0.256599634885788,-0.2908108830451965,-0.2458265870809555,-0.1631519496440887,-0.06765953451395035,0.01232947781682014,-0.004303109832108021,-0.07196264714002609,-0.05426191166043282,0.02090517990291119,-0.01116977445781231,-0.05475020781159401,-0.06262398511171341,-0.07437361031770706,-0.009765923023223877,0.01532029174268246,0.01660206913948059,0.09781182557344437,0.1623889952898026,0.221839040517807,0.2641682326793671,0.1919919401407242,0.1223181858658791,0.08514664322137833,0.03329569473862648,0.01770073547959328,-0.001831110566854477,0.007629627361893654,0.06750694662332535,0.06836146116256714,0.07696767896413803,0.1251258850097656,0.128513440489769,0.0952787846326828,0.01440473645925522,-0.0480056144297123,-0.1168553754687309,-0.1779534220695496,-0.1666310578584671,-0.2051149010658264,-0.2327036410570145,-0.2096011191606522,-0.176244392991066,-0.1478621810674667,-0.1556749194860458,-0.1663869172334671,-0.2142094224691391,-0.2500991821289062,-0.176244392991066,-0.03247169405221939,0.06173894554376602,0.06204412877559662,0.03479110077023506,0.05624561384320259,0.08960234373807907,0.1099887117743492,0.108462780714035,-0.01626636646687984,-0.1788079440593719,-0.2288277894258499,-0.1665700227022171,-0.07730338722467422,-0.03387554734945297,-0.0709555372595787,-0.1427045464515686,-0.1689504683017731,-0.173711359500885,-0.1775566935539246,-0.1679433584213257,-0.1511887013912201,-0.1514938771724701,-0.1314126998186111,-0.0475783571600914,0.04660176485776901,0.1270790696144104,0.1675160974264145,0.1467024683952332,0.1277199685573578,0.1156346350908279,0.09613330662250519,0.04306161776185036,-0.01831110566854477,-0.01748710684478283,0.00753807183355093,0.01770073547959328,-0.02981658466160297,-0.06421094387769699,-0.0198370311409235,-0.05050813406705856,-0.1759086847305298,-0.2510147392749786,-0.256752222776413,-0.256904810667038,-0.2382274866104126,-0.1767937242984772,-0.12485121935606,-0.1055940464138985,-0.01025421917438507,0.1124607101082802,0.1408123970031738,0.1819208413362503,0.2256843745708466,0.2307504564523697,0.2056337147951126,0.1918088346719742,0.1964476406574249,0.1702627688646317,0.1566209942102432,0.09329508244991302,0.04538102447986603,0.006164738908410072,-0.0874660462141037,-0.0955534502863884,-0.05465865135192871,-0.09051790088415146,-0.2020325362682343,-0.2960295379161835,-0.286843478679657,-0.2008423060178757,-0.1692556589841843,-0.1543931365013123,-0.1217993721365929,-0.1262245625257492,-0.1452681124210358,-0.2386547476053238,-0.3095492422580719,-0.2264778614044189,-0.1182592213153839,-0.1507309228181839,-0.2453077733516693,-0.3132725059986115,-0.3744620978832245,-0.3887142539024353,-0.4213995933532715,-0.3986327648162842,-0.2937711775302887,-0.2230292707681656,-0.07751701772212982,0.04538102447986603,0.07571642100811005,0.09622485935688019,0.04336680099368095,0.0079348124563694,0.03036591783165932,0.03765984252095222,0.007599108852446079,0.01168858911842108,0.05960264801979065,0.06018250063061714,0.0714743509888649,0.09634693711996078,0.1085848584771156,0.1281166970729828,0.14090396463871,0.2023377120494843,0.2493362277746201,0.2069765329360962,0.1659596562385559,0.160893589258194,0.1895809769630432,0.1974852681159973,0.171391949057579,0.1779229044914246,0.1788079440593719,0.126071959733963,0.04870754107832909,0.02719199284911156,0.04690694808959961,0.04434339329600334,-0.04715109616518021,-0.2235480844974518,-0.2605365216732025,-0.2304757833480835,-0.2457960695028305,-0.2106082290410995,-0.1324503272771835,0.01532029174268246,0.1287270784378052,0.130649745464325,0.1542405486106873,0.1839045435190201,0.156346321105957,0.1642506122589111,0.1506698876619339,0.07797478884458542,0.001709036529064178,-0.04364147037267685,-0.07843256741762161,-0.1173436716198921,-0.1172521114349365,-0.1337931454181671,-0.08462782949209213,0.02533036284148693,0.06442457437515259,0.1185033693909645,0.1995605379343033,0.1958983093500137,0.1545152068138123,0.1422467678785324,0.1389202624559402,0.1683095842599869,0.2388683706521988,0.2749107480049133,0.2473525255918503,0.2137821614742279,0.1896725296974182,0.1159093007445335,0.004974517039954662,-0.0632343515753746,-0.08520767837762833,-0.05005035549402237,-0.00634784996509552,-0.01132236700505018,-0.02374340035021305,-0.04886013269424438,-0.05508590862154961,-0.03415021300315857,-0.06897183507680893,-0.114413894712925,-0.079256571829319,-0.02084414288401604,0.01217688526958227,0.02127140201628208,0.02386547438800335,0.04583880305290222,0.06179998070001602,0.05188146606087685,0.06942960619926453,0.1142307817935944,0.146061584353447,0.1640980243682861,0.1338236629962921,0.1471602469682693,0.1702932864427567,0.1272621899843216,0.1032136008143425,0.1086153760552406,0.1337626278400421,0.1482589244842529,0.1537827700376511,0.1441083997488022,0.1076387837529182,0.07666249573230743,0.05203405767679214,0.0796227902173996,0.1337015926837921,0.1293984800577164,0.1110568568110466,0.06823939085006714,-0.01123081147670746,-0.09567552804946899,-0.1375164091587067,-0.1393780261278152,-0.1266518086194992,-0.04446546733379364,-0.01220740377902985,0.0005188146606087685,0.08066041767597198,0.1113620400428772,0.1386761069297791,0.141056552529335,0.0234076976776123,-0.1109958216547966,-0.1381267756223679,-0.0790734589099884,-0.005493331700563431,0.07812738418579102,0.1190527081489563,0.1174352243542671,0.1446882486343384,0.1325113624334335,0.09079256653785706,0.05948057398200035,-0.01269569993019104,-0.08829005062580109,-0.1106601133942604,-0.09848322719335556,-0.08209478855133057,-0.07528916001319885,-0.09982604533433914,-0.1281166970729828,-0.1543626189231873,-0.1653187721967697,-0.1547593623399734,-0.1419721096754074,-0.146000549197197,-0.2006897181272507,-0.2283394932746887,-0.2457655519247055,-0.2612079083919525,-0.1704458743333817,-0.1023895964026451,-0.1126438155770302,-0.08185064047574997,-0.03039643540978432,-0.006683553569018841,0.02597125247120857,0.07296975702047348,0.08835108578205109,0.07641834765672684,0.02630695514380932,-0.0472731702029705,-0.08127079159021378,-0.07406841963529587,-0.09277626872062683,-0.1118198186159134,-0.07818841934204102,-0.04150517284870148,0.01434369944036007,0.01205481123179197,-0.1273537427186966,-0.2184820026159286,-0.1904354989528656,-0.07223731279373169,0.1256752163171768,0.2386242300271988,0.1990417242050171,0.07531968504190445,0.001953184604644775,0.09021271765232086,0.2278206795454025,0.269539475440979,0.1881160885095596,0.0633869469165802,0.002838221378624439,-0.03582873195409775,-0.02182073518633842,0.09363079071044922,0.1999572813510895,0.2547074854373932,0.2307199388742447,0.1166112273931503,-0.01409955136477947,-0.07464827597141266,-0.08810693770647049,-0.1366008520126343,-0.1544541716575623,-0.1387066245079041,-0.1366618871688843,-0.1025727093219757,-0.06579791009426117,-0.02090517990291119,0.006775109097361565,0.0316782146692276,0.08304086327552795,0.128452405333519,0.171300396323204,0.1600390672683716,0.1395611464977264,0.1118808537721634,0.08008056879043579,0.08786278963088989,0.1202429309487343,0.1516769975423813,0.0712302029132843,-0.01388592179864645,0.08117923885583878,0.1967833489179611,0.189123198390007,0.1430402547121048,0.06524857133626938,0.03369243443012238,0.0718710869550705,0.04153569042682648,-0.01568651385605335,-0.03598132357001305,-0.01873836480081081,-0.01852473616600037,-0.01788384653627872,0.04480117186903954,0.04293954372406006,-0.06872768700122833,-0.1098361164331436,-0.08120975643396378,-0.1386455893516541,-0.1923581659793854,-0.1607104688882828,-0.1394695937633514,-0.2059694230556488,-0.2352366745471954,-0.1642506122589111,-0.1380962580442429,-0.09582812339067459,-0.07773064076900482,-0.1068147867918015,-0.04638813436031342,-0.02649006620049477,-0.06552323698997498,-0.1100192293524742,-0.2078920900821686,-0.2649311721324921,-0.2389294058084488,-0.1455732882022858,-0.004486220888793468,0.01687673665583134,-0.1060212999582291,-0.2022766768932343,-0.269783616065979,-0.3447370827198029,-0.3537400364875793,-0.3075960576534271,-0.2674031853675842,-0.256874293088913,-0.2633747458457947,-0.2402417063713074,-0.1582384705543518,-0.05282754078507423,0.008453627116978168,0.004791405983269215,-0.03064058348536491,-0.05218665301799774,-0.06247138977050781,-0.0714133158326149,-0.08038575202226639,-0.07284767925739288,-0.006714072078466415,0.09121982753276825,0.1568346172571182,0.1707815825939178,0.143375962972641,0.1209753751754761,0.126102477312088,0.125797301530838,0.09683523327112198,0.09308145195245743,0.1465193629264832,0.2102725356817245,0.2473525255918503,0.2374034821987152,0.1992553472518921,0.1151768565177917,0.02462843805551529,0.006042664870619774,0.02276680804789066,0.05294961482286453,0.05713064968585968,0.02032532729208469,0.04351939633488655,0.08523819595575333,0.06509598344564438,0.0554521307349205,0.09036530554294586,0.02395703084766865,-0.1183812990784645,-0.2028260082006454,-0.2164372652769089,-0.146122619509697,-0.09915463626384735,-0.08148442208766937,-0.1408429145812988,-0.1876583099365234,-0.1297647058963776,-0.1229895949363708,-0.03863643482327461,0.06604205816984177,0.08542130887508392,0.156254768371582,0.143620103597641,0.04651020839810371,0.04684591293334961,0.140934482216835,0.2398449629545212,0.2716147303581238,0.2849513292312622,0.3276467323303223,0.2985320687294006,0.1805780231952667,0.1019013002514839,0.07394634932279587,0.02002014219760895,-0.06683553755283356,-0.1252784878015518,-0.2143314927816391,-0.2653889656066895,-0.1872005313634872,-0.1702017337083817,-0.1604968458414078,-0.1146580427885056,-0.1781975775957108,-0.221625417470932,-0.2074037939310074,-0.2013306021690369,-0.2051454186439514,-0.2665181457996368,-0.3107394576072693,-0.3250831663608551,-0.330515444278717,-0.3075655400753021,-0.3031098246574402,-0.3024079203605652,-0.2235175669193268,-0.1311990767717361,-0.1538438051939011,-0.1944639384746552,-0.1402325481176376,-0.06863612681627274,-0.04934842884540558,-0.03549302741885185,0.01849421672523022,0.09985656291246414,0.1640980243682861,0.2003234922885895,0.2010864615440369,0.1679738759994507,0.1167027801275253,0.09308145195245743,0.1350138932466507,0.1822870522737503,0.2168340086936951,0.2244941592216492,0.2264473438262939,0.2350535541772842,0.219428077340126,0.2297128140926361,0.2448499947786331,0.2737205028533936,0.2787865698337555,0.1854915022850037,0.176427498459816,0.2178106009960175,0.2077089697122574,0.1947996467351913,0.1634571403264999,0.1756035089492798,0.1645558029413223,0.1351969987154007,0.1923581659793854,0.2059083878993988,0.1162450015544891,0.06482131779193878,0.006866664625704288,-0.07715079188346863,-0.1232642605900764,-0.08954130858182907,0.01486251410096884,0.07681509107351303,0.1143223345279694,0.09039582312107086,0.1068758219480515,0.1831415742635727,0.1703543215990067,0.2093264609575272,0.2407605201005936,0.1699270606040955,0.1945249736309052,0.1987975686788559,0.1200598180294037,0.08355967700481415,0.07296975702047348,0.1051667854189873,0.1018707826733589,0.01275673694908619,-0.09338664263486862,-0.1376079618930817,-0.1786858737468719,-0.1976073533296585,-0.1705069094896317,-0.1379436701536179,-0.02691732533276081,0.06045716628432274,0.03067110292613506,-0.01931821741163731,0.03820917382836342,0.1075472310185432,0.02218695729970932,-0.08279671519994736,-0.0869472324848175,-0.03387554734945297,0.02859584428369999,0.0477614663541317,0.04144413769245148,-0.03335672989487648,-0.1252174377441406,-0.114474929869175,-0.1154820397496223,-0.1238135918974876,-0.1040986329317093,-0.1140171512961388,-0.07415997982025146,0.03353984281420708,0.1240272223949432,0.1790520995855331,0.2003540098667145,0.2018494158983231,0.1973631978034973,0.1984923928976059,0.2143620103597641,0.2283700108528137,0.2557451128959656,0.282021552324295,0.3121738433837891,0.3277382850646973,0.3121433258056641,0.2706991732120514,0.176030769944191,0.1375164091587067,0.1578417271375656,0.1644947677850723,0.109714038670063,0.002136295661330223,-0.02179021574556828,-0.02630695514380932,0.00555436871945858,0.0631733164191246,0.01403851434588432,-0.1177709251642227,-0.1982787549495697,-0.158635213971138,-0.05230872705578804,0.04361094906926155,0.007599108852446079,-0.04602191224694252,-0.09274575114250183,-0.09027375280857086,-0.04614398628473282,-0.08206427097320557,-0.08783227205276489,-0.1345866322517395,-0.1668446958065033,-0.1901913583278656,-0.252418577671051,-0.2424085140228271,-0.2098147571086884,-0.08307138085365295,0.01882992126047611,-0.01986755058169365,-0.03787346929311752,-0.01693777367472649,0.002227851189672947,0.01220740377902985,0.001007110811769962,-0.04223761707544327,-0.06573686748743057,-0.06302072107791901,-0.03378399088978767,0.0318613238632679,0.1040070801973343,0.1312601119279861,0.09936826676130295,0.05429242923855782,0.01300088502466679,0.0201727356761694,0.0320444367825985,0.02349925227463245,0.01886043883860111,-0.009338663890957832,-0.01852473616600037,-0.04422131925821304,-0.1620838046073914,-0.2460097074508667,-0.2139652669429779,-0.1591540277004242,-0.109622485935688,-0.05005035549402237,-0.01535081025213003,0.02084414288401604,0.09344767779111862,0.1390728503465652,0.1193578913807869,0.04498428478837013,-0.03299050778150558,-0.03118991665542126,0.0200811792165041,0.04556413367390633,0.03836176544427872,0.07373271882534027,0.0717490166425705,-0.04632709920406342,-0.1185033693909645,-0.1627857238054276,-0.2295297086238861,-0.2814416885375977,-0.2911160588264465,-0.2578814029693604,-0.2658772468566895,-0.2656941413879395,-0.208868682384491,-0.1497238129377365,-0.09384441375732422,-0.04297006130218506,-0.03704947233200073,-0.1048310771584511,-0.1875362396240234,-0.2323068976402283,-0.2358775585889816,-0.1510055810213089,-0.01666310615837574,0.04599139466881752,0.04184087738394737,0.01074251532554626,0.002014221623539925,0.004791405983269215,-0.01080355234444141,-0.00277718435972929,0.039613027125597,0.06454664468765259,-0.0039674062281847,-0.08017212152481079,-0.1325113624334335,-0.1523789167404175,-0.1616870611906052,-0.1579332798719406,-0.1323892921209335,-0.1290627717971802,-0.06552323698997498,0.003204443491995335,0.07034516334533691,0.1541795134544373,0.188940092921257,0.1621143221855164,0.1556444019079208,0.1926328390836716,0.2253181487321854,0.2292550504207611,0.1658375859260559,0.1138645559549332,0.1036713793873787,0.1467024683952332,0.2164983004331589,0.2540665864944458,0.239143043756485,0.1812799423933029,0.1853694319725037,0.2103030532598495,0.2122257202863693,0.2453382909297943,0.2602007985115051,0.2761009633541107,0.3236792981624603,0.317728191614151,0.2881862819194794,0.2834253907203674,0.2744834721088409,0.2143009752035141,0.176396980881691,0.2322763800621033,0.2491531074047089,0.2292855679988861,0.1884517967700958,0.1522263288497925,0.109622485935688,0.006653035059571266,-0.01150547806173563,-0.03070162050426006,-0.1026337444782257,-0.0552385039627552,0.04956205934286118,0.09042634069919586,0.08297982811927795,0.07690664380788803,0.08368175476789474,0.07315286993980408,0.0553910955786705,0.01950132846832275,-0.03656117618083954,-0.06045716628432274,-0.07678457349538803,-0.1134678199887276,-0.1671498715877533,-0.20639668405056,-0.2451857030391693,-0.2669148743152618,-0.252296507358551,-0.2389599233865738,-0.2309030443429947,-0.287179172039032,-0.3094576895236969,-0.2195196449756622,-0.08337657153606415,0.04522843286395073,0.1109958216547966,0.1351054459810257,0.1327250003814697,0.1390423327684402,0.1381878107786179,0.09042634069919586,0.0479140616953373,0.04672383889555931,0.09887997061014175,0.1886654198169708,0.2755821347236633,0.3191320598125458,0.2938322126865387,0.1734061688184738,0.02481154911220074,-0.04925687611103058,-0.06210516765713692,-0.05078279972076416,-0.01657155156135559,0.05169835686683655,0.125858336687088,0.1663563996553421,0.1527451425790787,0.1110873743891716,0.1087374463677406,0.1530503183603287,0.1479232162237167,0.08032471686601639,0.02700888179242611,0.03408917412161827,0.1167332977056503,0.204199343919754,0.2452467381954193,0.2062135636806488,0.1053193733096123,0.01196325570344925,-0.04565569013357162,-0.03521836176514626,0.02655110321938992,0.1134373024106026,0.204260379076004,0.2293160855770111,0.1856746077537537,0.1654408425092697,0.1660512089729309,0.1355021893978119,0.1193884089589119,0.1374248415231705,0.1449629217386246,0.1238746270537376,0.110934779047966,0.1115756705403328,0.07354960590600967,0.01672414317727089,0.004791405983269215,0.02035584673285484,-0.01129184849560261,-0.09259315580129623,-0.1432843953371048,-0.1246070712804794,-0.05148472636938095,0.0159611813724041,0.009735404513776302,-0.0394299142062664,-0.0238044373691082,0.08328501135110855,0.1843012720346451,0.2226630449295044,0.2279427498579025,0.2219916433095932,0.2004760950803757,0.1497848480939865,0.1299172937870026,0.1750541776418686,0.2153691202402115,0.2195196449756622,0.208929717540741,0.2162236422300339,0.2153386026620865,0.1869258731603622,0.1221961155533791,0.06253242492675781,0.03888058289885521,-0.01101718191057444,-0.07693716138601303,-0.1368449926376343,-0.1326639652252197,-0.09070101380348206,-0.06524857133626938,-0.03595080599188805,-0.07333597540855408,-0.1178624853491783,-0.08484145998954773,-0.0632343515753746,-0.1062654480338097,-0.173955500125885,-0.2180547565221786,-0.2280037850141525,-0.1917172819375992,-0.09909360110759735,-0.03875850886106491,-0.07742545753717422,-0.1512802541255951,-0.1900387555360794,-0.1872920989990234,-0.1492355167865753,-0.08304086327552795,-0.04654072597622871,-0.03878902643918991,-0.005401776172220707,0.04705954343080521,0.1038544848561287,0.158452108502388,0.1946165412664413,0.1917477995157242,0.1647694259881973,0.1652272045612335,0.1720938682556152,0.1481368392705917,0.09939878433942795,0.1113010048866272,0.1702932864427567,0.1068147867918015,-0.006164738908410072,-0.07315286993980408,-0.07760857045650482,-0.004608294926583767,-0.0002136295661330223,-0.04522843286395073,-0.05279702320694923,-0.08902249485254288,-0.1470686942338943,-0.1817377209663391,-0.1770073622465134,-0.1845454275608063,-0.2025818675756454,-0.1963866055011749,-0.2132633477449417,-0.1998046785593033,-0.1557054370641708,-0.1189306303858757,-0.1127964109182358,-0.1314126998186111,-0.1555223315954208,-0.1599780321121216,-0.09961241483688354,-0.08114871382713318,-0.08563493937253952,-0.0007629627361893654,0.1573839485645294,0.2555314898490906,0.2671895623207092,0.2529679238796234,0.2153996378183365,0.2470473349094391,0.2813501358032227,0.2371898591518402,0.234290599822998,0.2660603523254395,0.2642292678356171,0.2293466031551361,0.1300393640995026,-0.007202368229627609,-0.1020538955926895,-0.1206396669149399,-0.1196630746126175,-0.1551255881786346,-0.2113101631402969,-0.2573931217193604,-0.2707296907901764,-0.2848902940750122,-0.2865077555179596,-0.2982878983020782,-0.3316446542739868,-0.3288674652576447,-0.3448896706104279,-0.3413495421409607,-0.2672200798988342,-0.2187871932983398,-0.1789910644292831,-0.114413894712925,-0.08651997148990631,-0.07742545753717422,-0.04928739368915558,-0.01910458691418171,0.01251258887350559,0.06436353921890259,0.1170079633593559,0.1400799602270126,0.1546067744493484,0.1694997996091843,0.1816461682319641,0.188909575343132,0.1871394962072372,0.1965697258710861,0.2069460153579712,0.1958677917718887,0.1442304700613022,0.04275643080472946,-0.08117923885583878,-0.1791436523199081,-0.2262642234563828,-0.1646473556756973,0.01092562638223171,0.1439252942800522,0.1834772825241089,0.1852473467588425,0.1692251414060593,0.130832850933075,0.07388531416654587,0.03265480697154999,0.06259346008300781,0.1546983271837234,0.2094790488481522,0.1814630627632141,0.09073153138160706,-0.01495406962931156,-0.07089449465274811,-0.05670339241623878,-0.01745658740401268,-0.008270516060292721,-0.05404828116297722,-0.1262245625257492,-0.1931211352348328,-0.2287057042121887,-0.2402722239494324,-0.2261726707220078,-0.1455122530460358,-0.006408886983990669,0.1355632245540619,0.2052674889564514,0.221869558095932,0.2073122411966324,0.1659901738166809,0.1199072226881981,0.04263435676693916,-0.03915524855256081,-0.09759819507598877,-0.1472518146038055,-0.204138308763504,-0.256386011838913,-0.2833338379859924,-0.2926419973373413,-0.2804650962352753,-0.2585223019123077,-0.2407300025224686,-0.2150639295578003,-0.173955500125885,-0.1201208531856537,-0.06991790235042572,-0.04324472695589066,-0.05438398569822311,-0.09784234315156937,-0.1363872140645981,-0.1416974365711212,-0.1226538866758347,-0.08859523385763168,-0.06137272343039513,-0.06012146547436714,-0.0472426526248455,-9.155552834272385e-05,0.05267494916915894,0.09204382449388504,0.1291238069534302,0.1702322512865067,0.1990722417831421,0.1929074972867966,0.1312906295061111,0.05960264801979065,0.05761894583702087,0.1056550815701485,0.1388592123985291,0.1398663222789764,0.1371501833200455,0.1164586320519447,0.03216651082038879,-0.05758842825889587,-0.07287820428609848,-0.03061006590723991,0.03219702839851379,0.09237952530384064,0.1216467767953873,0.1256446987390518,0.09176915884017944,0.02935880608856678,-0.01464888453483582,-0.04715109616518021,-0.03399762138724327,0.04950102418661118,0.113223671913147,0.04257332161068916,-0.1151463389396667,-0.1941892802715302,-0.1575670689344406,-0.08059938251972198,-0.06610309332609177,-0.1011383384466171,-0.1042512282729149,-0.08972442150115967,-0.08807642012834549,-0.1056245639920235,-0.1104159653186798,-0.08624530583620071,-0.06741538643836975,-0.07977538555860519,-0.1156041175127029,-0.1536301821470261,-0.1698660254478455,-0.1662037968635559,-0.1814935803413391,-0.2159489691257477,-0.241828665137291,-0.2461928129196167,-0.2081972658634186,-0.1028778925538063,0.01373332925140858,0.05081331729888916,0.0002441480755805969,-0.08212530612945557,-0.143589586019516,-0.1827753484249115,-0.2082277834415436,-0.2206793427467346,-0.2305978536605835,-0.2450331151485443,-0.2663655579090118,-0.2834864258766174,-0.2892239093780518,-0.287392795085907,-0.2750938534736633,-0.23929563164711,-0.1841486841440201,-0.1428266316652298,-0.08877834677696228,0.01355021819472313,0.1088595241308212,0.1663563996553421,0.1953489780426025,0.1969359368085861,0.1970885396003723,0.2070070505142212,0.2097537219524384,0.1950743198394775,0.1716971397399902,0.156315803527832,0.1447798162698746,0.1337015926837921,0.1394085586071014,0.1649830639362335,0.1980040967464447,0.2255012691020966,0.2327036410570145,0.1687368452548981,0.04345835745334625,-0.04809717088937759,-0.128269299864769,-0.219306007027626,-0.2730796337127686,-0.300057977437973,-0.3165379762649536,-0.329660952091217,-0.3410443365573883,-0.3498031497001648,-0.3538010716438293,-0.3509933650493622,-0.3461714386940002,-0.3426007926464081,-0.3435468673706055,-0.3414410948753357,-0.3328348696231842,-0.304391622543335,-0.2595904469490051,-0.2220526784658432,-0.2244941592216492,-0.2703329622745514,-0.3093966543674469,-0.3291726410388947,-0.3241370916366577,-0.2626117765903473,-0.1691030561923981,-0.09033478796482086,-0.03576769307255745,-0.01220740377902985,-0.01467940304428339,-0.009399700909852982,-0.003326517529785633,-0.008514664135873318,0.01168858911842108,0.0633259043097496,0.1204260364174843,0.1595812886953354,0.1795098781585693,0.1797845363616943,0.1881466060876846,0.2006286829710007,0.2145145982503891,0.2471083700656891,0.2506180107593536,0.2432325184345245,0.256965845823288,0.2750328183174133,0.2708517611026764,0.2771080732345581,0.2830591797828674,0.2310251146554947,0.2149723768234253,0.2432325184345245,0.2471083700656891,0.2712180018424988,0.2980742752552032,0.2336191833019257,0.09109774976968765,-0.01449629198759794,-0.07879879325628281,-0.1620532870292664,-0.2273629009723663,-0.2461317777633667,-0.2554399371147156,-0.2784813940525055,-0.3131199181079865,-0.3386639058589935,-0.3309122025966644,-0.3056428730487823,-0.2892849445343018,-0.300119012594223,-0.3247474730014801,-0.3281350135803223,-0.1970885396003723,0.05301064997911453,0.1998046785593033,0.2428662925958633,0.2648701369762421,0.2661824524402618,0.2705160677433014,0.2838526666164398,0.3017059862613678,0.2992950081825256,0.2852870225906372,0.2605975568294525,0.1995300203561783,0.1055940464138985,0.05713064968585968,0.1200293004512787,0.2009949088096619,0.2323374152183533,0.2182988971471786,0.1636097282171249,0.0711691677570343,-0.0241401419043541,-0.07827997952699661,-0.1114841178059578,-0.1487777382135391,-0.189153715968132,-0.1987975686788559,-0.1944944560527802,-0.1901303082704544,-0.2036805301904678,-0.2317880839109421,-0.2315439283847809,-0.2428052574396133,-0.221472829580307,-0.1567125469446182,-0.1553697288036346,-0.1893063187599182,-0.1861018687486649,-0.1504257321357727,-0.1272316724061966,-0.1446882486343384,-0.1535080969333649,-0.06231879815459251,0.1094393730163574,0.2269051223993301,0.2605670392513275,0.2490615546703339,0.204107791185379,0.143436998128891,0.07086397707462311,0.0002136295661330223,-0.05026398599147797,-0.06683553755283356,-0.06527908891439438,-0.08111819624900818,-0.08478041738271713,-0.01089510787278414,0.1289407014846802,0.2408520728349686,0.2880336940288544,0.3030487895011902,0.3074739873409271,0.3134861290454865,0.3277382850646973,0.3405865728855133,0.3331095278263092,0.2901394665241241,0.2308420091867447,0.2057863026857376,0.2119510471820831,0.1983703076839447,0.1185949295759201,-0.0135807367041707,-0.1299172937870026,-0.1956236511468887,-0.2206488251686096,-0.2236701548099518,-0.2164067476987839,-0.1989501565694809,-0.1729789078235626,-0.1744437962770462,-0.2036500126123428,-0.208838164806366,-0.1583605408668518,-0.07068087160587311,-0.004638813436031342,-0.005890072323381901,-0.07315286993980408,-0.1463362574577332,-0.1745353490114212,-0.1806085407733917,-0.1997436434030533,-0.2219306081533432,-0.2361827492713928,-0.2421033382415771,-0.2502212524414062,-0.2619098424911499,-0.2659687995910645,-0.2410046756267548,-0.1616870611906052,-0.07074190676212311,-0.03247169405221939,-0.06869716197252274,-0.1219519674777985,-0.1524399518966675,-0.1832941621541977,-0.1664174348115921,-0.07324442267417908,0.02157658711075783,0.05258339270949364,0.03381450846791267,0.0400708019733429,0.1011078208684921,0.1757866144180298,0.234534740447998,0.2679830193519592,0.2580950260162354,0.2000488340854645,0.1438947767019272,0.1053193733096123,0.04440443217754364,0.03482161834836006,0.128269299864769,0.2036805301904678,0.1832636445760727,0.128299817442894,0.1358378827571869,0.1941587626934052,0.2384411096572876,0.269966721534729,0.2981353104114532,0.3156529366970062,0.3023468852043152,0.1932737231254578,0.0274971779435873,-0.07309182733297348,-0.1150852963328362,-0.1146275252103806,-0.07483138889074326,0.004211554303765297,0.1140476688742638,0.1766106188297272,0.1552476584911346,0.0710776075720787,-0.02426221594214439,-0.07010101526975632,-0.05597094818949699,0.01672414317727089,0.09393597394227982,0.107181005179882,0.1060823425650597,0.1404767036437988,0.1728568375110626,0.1620532870292664,0.1175267770886421,0.07223731279373169,0.08371227234601974,0.1380352228879929,0.1892758011817932,0.2188177108764648,0.2117374241352081,0.1604663282632828,0.0795312374830246,0.06076235324144363,0.1013824865221977,0.1297647058963776,0.06460768729448318,-0.04950102418661118,-0.09729301184415817,-0.1356242597103119,-0.1606189161539078,-0.1670278012752533,-0.2028260082006454,-0.2199468910694122,-0.1964476406574249,-0.1607715040445328,-0.1455732882022858,-0.1566820293664932,-0.1582995057106018,-0.1644032150506973,-0.1861018687486649,-0.208838164806366,-0.2206488251686096,-0.2077089697122574,-0.1535080969333649,-0.01297036651521921,0.146061584353447,0.2347788959741592,0.2590105831623077,0.2682882249355316,0.2838526666164398,0.304879903793335,0.3394268751144409,0.3375957608222961,0.3433942794799805,0.3569139540195465,0.3120212554931641,0.209051787853241,0.0475783571600914,-0.01898251287639141,0.06091494485735893,0.08798485994338989,0.006958220154047012,-0.04065065458416939,0.01986755058169365,0.1043733060359955,0.1244850009679794,0.04327524825930595,-0.09439375251531601,-0.171330913901329,-0.1800286918878555,-0.1883602440357208,-0.219244971871376,-0.2452772557735443,-0.2423474788665771,-0.2488479316234589,-0.2893764972686768,-0.3279213905334473,-0.3374736905097961,-0.3064058423042297,-0.2337717860937119,-0.1584215760231018,-0.1245155185461044,-0.1204870790243149,-0.06006042659282684,0.07586901634931564,0.1798455715179443,0.2205877900123596,0.2403332591056824,0.2229377180337906,0.1452986299991608,-0.0008850367739796638,-0.186468094587326,-0.3006073236465454,-0.334482878446579,-0.3459578156471252,-0.3534653782844543,-0.365703284740448,-0.3278298377990723,-0.1725211292505264,0.04327524825930595,0.1368755102157593,0.1500900238752365,0.1769157946109772,0.1522568464279175,0.113223671913147,0.0953703448176384,0.1326944828033447,0.2080141603946686,0.2505874931812286,0.2788781523704529,0.2856227159500122,0.2878811061382294,0.2761925160884857,0.1819513589143753,0.05920590832829475,-0.001007110811769962,0.04474013671278954,0.1639149188995361,0.2559892535209656,0.2255928218364716,0.04956205934286118,-0.1153294444084167,-0.1318704783916473,0.009796441532671452,0.1657765507698059,0.1985229104757309,0.1675160974264145,0.1401409953832626,0.1482589244842529,0.161107212305069,0.1139561161398888,-0.007843256928026676,-0.1329691410064697,-0.1934568285942078,-0.2003234922885895,-0.1868343204259872,-0.1989196389913559,-0.2333445250988007,-0.252204954624176,-0.2377697080373764,-0.1858577281236649,-0.1154515221714973,-0.07003998011350632,-0.06753746420145035,-0.06524857133626938,-0.02114932797849178,0.0714438334107399,0.1496627777814865,0.1767937242984772,0.2033143043518066,0.234290599822998,0.2585223019123077,0.2762840688228607,0.2932523488998413,0.3083895444869995,0.3154393136501312,0.3367107212543488,0.3556321859359741,0.3544724881649017,0.3427228629589081,0.335398405790329,0.3246558904647827,0.2079531252384186,-0.004181035794317722,-0.158909872174263,-0.2305368185043335,-0.2560502886772156,-0.2575762271881104,-0.2623371183872223,-0.2623981535434723,-0.2604449689388275,-0.2709433138370514,-0.2855311632156372,-0.2964568138122559,-0.3034150302410126,-0.304208517074585,-0.3219397664070129,-0.3535874485969543,-0.3703421056270599,-0.3863338232040405,-0.3810846209526062,-0.3532517552375793,-0.2723471820354462,-0.1088290065526962,0.03265480697154999,0.1149021908640862,0.1674550622701645,0.1868648380041122,0.2136295735836029,0.2661214172840118,0.3085421323776245,0.3597826957702637,0.3893856704235077,0.3699148595333099,0.3531296849250793,0.352397233247757,0.3676564693450928,0.3712576627731323,0.3376873135566711,0.2634357810020447,0.1601611375808716,0.1156346350908279,0.158574178814888,0.1899166852235794,0.0954924151301384,-0.07715079188346863,-0.1687063276767731,-0.1670583188533783,-0.1359904855489731,-0.1134373024106026,-0.1060518175363541,-0.1012909337878227,-0.1005279719829559,-0.1273232251405716,-0.1794183105230331,-0.2181157916784286,-0.2455824464559555,-0.2656025886535645,-0.2728354632854462,-0.2772911787033081,-0.2887051105499268,-0.3008209466934204,-0.2883388698101044,-0.1735282391309738,0.03308206424117088,0.176427498459816,0.2184514850378036,0.2134769707918167,0.1472518146038055,0.001831110566854477,-0.1456648409366608,-0.2280953377485275,-0.2687459886074066,-0.2912686467170715,-0.3097933828830719,-0.3306070268154144,-0.3420819640159607,-0.3443708717823029,-0.3358561992645264,-0.3103427290916443,-0.2732322216033936,-0.2463454157114029,-0.2574541568756104,-0.2860805094242096,-0.3102206587791443,-0.3332926332950592,-0.3510544002056122,-0.3594470024108887,-0.3554795980453491,-0.3401287794113159,-0.3267616927623749,-0.3387249410152435,-0.3666798770427704,-0.3583788573741913,-0.2336191833019257,-0.02301095612347126,0.1233558133244514,0.1849116533994675,0.219244971871376,0.2386852651834488,0.2440260052680969,0.2313303053379059,0.2161626070737839,0.2161626070737839,0.2266914844512939,0.2339854091405869,0.2298043817281723,0.2105166763067245,0.1759086847305298,0.1190221905708313,0.05298013240098953,0.006530961021780968,-0.02728354744613171,-0.06164738908410072,-0.1204260364174843,-0.1854609847068787,-0.221869558095932,-0.251625120639801,-0.2710959315299988,-0.2815637588500977,-0.2943204939365387,-0.2966399192810059,-0.2886745929718018,-0.2587969601154327,-0.1894894242286682,-0.07461775839328766,0.05093539133667946,0.1208838149905205,0.1505783200263977,0.1969969719648361,0.2489700019359589,0.2890102863311768,0.3269447982311249,0.3375957608222961,0.3090914785861969,0.2729880809783936,0.2339243739843369,0.2229377180337906,0.2604144513607025,0.3032624423503876,0.3310342729091644,0.3319498300552368,0.3272194564342499,0.3324686288833618,0.3221228718757629,0.2665486633777618,0.189184233546257,0.1690725386142731,0.1924497187137604,0.2187871932983398,0.2510452568531036,0.2689290940761566,0.241920217871666,0.1709036529064178,0.1187169998884201,0.1130710765719414,0.1184118166565895,0.1081575974822044,0.1160618886351585,0.194036677479744,0.2769249677658081,0.2807703018188477,0.1781060248613358,0.03863643482327461,-0.04553361609578133,-0.04635761678218842,0.0795312374830246,0.2402111887931824,0.3141880631446838,0.2887356281280518,0.1822260171175003,0.07364116609096527,-0.009643848985433578,-0.07507553696632385,-0.07754753530025482,-0.02154606766998768,0.07214576005935669,0.1755729913711548,0.2301705926656723,0.1226538866758347,-0.09442427009344101,-0.2029175758361816,-0.221808522939682,-0.2131717950105667,-0.1904965341091156,-0.1839960962533951,-0.1768547594547272,-0.1828669160604477,-0.2145451158285141,-0.2508621513843536,-0.2553483545780182,-0.1286965608596802,0.109561450779438,0.2650227248668671,0.3140659928321838,0.3180333971977234,0.2542191743850708,0.1322061866521835,0.01846369914710522,-0.04553361609578133,-0.07473982870578766,-0.0949125662446022,-0.1174657419323921,-0.09564501047134399,0.00436414685100317,0.1408123970031738,0.2576982975006104,0.3162633180618286,0.3087862730026245,0.2081667482852936,0.04876857995986938,-0.009643848985433578,0.06067079678177834,0.06701865047216415,-0.07025361061096191,-0.1875972747802734,-0.2211676388978958,-0.1794488430023193,-0.03607288002967834,0.03003021329641342,-0.07757805287837982,-0.188726469874382,-0.2286141514778137,-0.2280037850141525,-0.2099368274211884,-0.2177190482616425,-0.2458265870809555,-0.2629779875278473,-0.2752159237861633,-0.2865993082523346,-0.299783319234848,-0.3182775378227234,-0.3455610871315002,-0.3668324947357178,-0.3626514375209808,-0.3326212465763092,-0.2147892713546753,-0.04831080138683319,0.05725272372364998,0.1423078030347824,0.224127933382988,0.2726828753948212,0.300271600484848,0.3115634620189667,0.3123569488525391,0.3107394576072693,0.3067720532417297,0.2939848005771637,0.2547990381717682,0.1847895681858063,0.0714743509888649,-0.04409924522042274,-0.07852412760257721,-0.06720175594091415,-0.08407849073410034,-0.07577745616436005,0.01251258887350559,0.1039460450410843,0.1163365617394447,0.02505569718778133,-0.107211522758007,-0.1745658814907074,-0.1754509061574936,-0.1608325392007828,-0.1774651259183884,-0.2308420091867447,-0.2676168084144592,-0.2488479316234589,-0.2076479345560074,-0.2138737142086029,-0.2456434816122055,-0.2680746018886566,-0.2849818468093872,-0.2856227159500122,-0.2846461236476898,-0.2764366567134857,-0.251594603061676,-0.2382885217666626,-0.2405163794755936,-0.2497024387121201,-0.2325205206871033,-0.1901913583278656,-0.2050843834877014,-0.2492751926183701,-0.2443922311067581,-0.161290317773819,-0.05975524336099625,-0.03753776848316193,-0.05355998501181602,-0.04016235843300819,-0.05377361550927162,-0.1653798073530197,-0.2854701280593872,-0.3376567959785461,-0.3342387080192566,-0.2268440872430801,-0.01580858789384365,0.14108707010746,0.1838129758834839,0.1212500408291817,-0.05078279972076416,-0.1803033500909805,-0.1635792106389999,-0.008209479041397572,0.1687368452548981,0.2082583159208298,0.02981658466160297,-0.2029175758361816,-0.2790002226829529,-0.2863551676273346,-0.2789391875267029,-0.2456129640340805,-0.1855525374412537,-0.1033661887049675,-0.05355998501181602,-0.002471999265253544,0.1074251532554626,0.2134464532136917,0.2594988942146301,0.2599871754646301,0.1591235101222992,-0.01733451336622238,-0.05059969052672386,0.09350871294736862,0.2101199328899384,0.2395397871732712,0.2446363717317581,0.2530899941921234,0.2608111798763275,0.2621539831161499,0.2811670303344727,0.2943204939365387,0.28205206990242,0.2285225987434387,0.1263771504163742,0.08313242346048355,0.1326639652252197,0.1981566846370697,0.2382580041885376,0.2551347315311432,0.2650532424449921,0.2710654139518738,0.2500381469726562,0.2093569785356522,0.2187261581420898,0.2673726677894592,0.2966399192810059,0.3065279126167297,0.3105258345603943,0.3068330883979797,0.2723166644573212,0.1853999495506287,0.1245155185461044,0.1594897359609604,0.1995605379343033,0.161107212305069,0.07068087160587311,-0.002594073303043842,-0.05023346841335297,-0.03375347331166267,0.09878841787576675,0.2120425999164581,0.1078524142503738,-0.1139561161398888,-0.2139347493648529,-0.2201300114393234,-0.1957457214593887,-0.1476485431194305,-0.1214026287198067,-0.1070284098386765,-0.1037934496998787,-0.1571092903614044,-0.2340159267187119,-0.2711569666862488,-0.2919400632381439,-0.3122043609619141,-0.3421429991722107,-0.3626209199428558,-0.3384808003902435,-0.2952970862388611,-0.2299264520406723,-0.1796624660491943,-0.1062654480338097,0.05984679609537125,0.1871394962072372,0.2188482284545898,0.2274239361286163,0.2505874931812286,0.2762535512447357,0.2770775556564331,0.2646565139293671,0.2663960754871368,0.281777411699295,0.2968840599060059,0.3148594498634338,0.3432722091674805,0.378093808889389,0.3963744044303894,0.3973204791545868,0.3944517374038696,0.3852961957454681,0.3741874396800995,0.3585314452648163,0.3400982618331909,0.3426618278026581,0.3773308396339417,0.4223456382751465,0.4314096570014954,0.3998534977436066,0.3610950112342834,0.2504043579101562,0.07007049769163132,-0.01437421794980764,-0.01763969846069813,-0.04232917353510857,-0.07257301360368729,-0.09079256653785706,-0.05905331671237946,-0.004425183869898319,-0.02795495465397835,-0.107119970023632,-0.1648915112018585,-0.1855830550193787,-0.1872920989990234,-0.1942197978496552,-0.206305131316185,-0.2094485312700272,-0.1973021626472473,-0.1557359546422958,-0.109714038670063,-0.1360210031270981,-0.2059389054775238,-0.2485732585191727,-0.2558977007865906,-0.1449018865823746,0.06723227351903915,0.2113711982965469,0.2768944501876831,0.3067720532417297,0.2712180018424988,0.1685232073068619,0.03479110077023506,-0.06656087189912796,-0.06299020349979401,0.04605242982506752,0.1520737260580063,0.2023987621068954,0.2267525196075439,0.1822870522737503,0.0320139154791832,-0.1181066334247589,-0.1745658814907074,-0.176091805100441,-0.1709952056407928,-0.1700186133384705,-0.156163215637207,-0.1463972926139832,-0.1844843924045563,-0.2341074794530869,-0.2596209645271301,-0.2720725238323212,-0.2668538391590118,-0.2585833370685577,-0.2187871932983398,-0.08908353000879288,0.04467909783124924,0.1142612993717194,0.143589586019516,0.1118808537721634,-0.001251258887350559,-0.1379741877317429,-0.2051149010658264,-0.1850337237119675,-0.1293679624795914,-0.09595019370317459,-0.0871608629822731,-0.09134189784526825,-0.1018707826733589,-0.09915463626384735,-0.05038606002926826,0.005829035304486752,-0.05862605571746826,-0.186315506696701,-0.2493667453527451,-0.2652058601379395,-0.2738425731658936,-0.2813501358032227,-0.2910855412483215,-0.3059480488300323,-0.3225196003913879,-0.2991729378700256,-0.09442427009344101,0.158635213971138,0.2404553294181824,0.2256233394145966,0.08517716079950333,-0.124698631465435,-0.2199468910694122,-0.2110049724578857,-0.1395611464977264,-0.01684621721506119,0.1033967137336731,0.1337321102619171,0.05023346841335297,-0.04425184056162834,-0.08975493907928467,-0.1170995235443115,-0.0716269388794899,0.07351908832788467,0.2032837867736816,0.2628864347934723,0.3014618456363678,0.3228858411312103,0.3092440664768219,0.2477492541074753,0.1850642412900925,0.2051149010658264,0.2380748987197876,0.1828058660030365,0.09048738330602646,0.1304361075162888,0.2402111887931824,0.2812891006469727,0.2174443751573563,0.06988738477230072,0.09884945303201675,0.2552262842655182,0.3334147036075592,0.3695486187934875,0.3268227279186249,0.1472823321819305,-0.06689657270908356,-0.1859797984361649,-0.2379833310842514,-0.269569993019104,-0.2841578423976898,-0.282326728105545,-0.2717368006706238,-0.2540971040725708,-0.2127750515937805,-0.1795403957366943,-0.1869869083166122,-0.2140873372554779,-0.2249824553728104,-0.1514633595943451,-0.0710165724158287,-0.1201208531856537,-0.1836909055709839,-0.1673024743795395,-0.1376995146274567,-0.1113620400428772,-0.08340708911418915,-0.06952116638422012,-0.04370250552892685,-0.02203436382114887,-0.03494369238615036,-0.0948820486664772,-0.1854304671287537,-0.2352061569690704,-0.203863650560379,-0.09649952501058578,0.02023377269506454,0.09591967612504959,0.1089510768651962,0.0789819061756134,0.09878841787576675,0.1369975954294205,0.08468886464834213,-0.03592028468847275,-0.1390118151903152,-0.1856746077537537,-0.1571398079395294,-0.03238013759255409,0.06527908891439438,-0.02438428997993469,-0.1877803951501846,-0.2727744281291962,-0.3064973950386047,-0.3278603553771973,-0.3330179750919342,-0.3497115969657898,-0.3840143978595734,-0.4121219515800476,-0.4282662570476532,-0.395947128534317,-0.3137607872486115,-0.1367839574813843,-0.03714102506637573,-0.1573839485645294,-0.2736594676971436,-0.3281655311584473,-0.3541978299617767,-0.3243812322616577,-0.1725211292505264,0.04196295142173767,0.1504562497138977,0.1902829110622406,0.2165593504905701,0.2276375591754913,0.2325510382652283,0.239265114068985,0.2605060040950775,0.2895596325397491,0.3018890917301178,0.2706686556339264,0.2301705926656723,0.2371593415737152,0.2723166644573212,0.2912991642951965,0.2855616807937622,0.2721335589885712,0.2770470380783081,0.3064973950386047,0.3214514553546906,0.2939237654209137,0.1521652936935425,-0.08221686631441116,-0.2255928218364716,-0.2460707426071167,-0.1046479716897011,0.1174047067761421,0.2154301553964615,0.2382580041885376,0.2454298585653305,0.236610010266304,0.234290599822998,0.241645559668541,0.251533567905426,0.2652363777160645,0.2782677710056305,0.2582170963287354,0.2047181576490402,0.188787505030632,0.2291024476289749,0.2684102952480316,0.2861110270023346,0.2797937095165253,0.2314218580722809,0.1704458743333817,0.1615955084562302,0.1640064716339111,0.1499069184064865,0.1793267577886581,0.2134159356355667,0.1474654376506805,0.009247108362615108,-0.08676411956548691,-0.1233863309025764,-0.09945981949567795,0.02096621692180634,0.1320535838603973,0.1015045642852783,0.0155034027993679,0.02691732533276081,0.1000091582536697,0.05410931631922722,-0.09195227175951004,-0.1721244007349014,-0.1997741609811783,-0.2278817147016525,-0.2469252645969391,-0.2514114677906036,-0.2506180107593536,-0.2620319128036499,-0.2860499918460846,-0.3095492422580719,-0.3087252378463745,-0.2961821258068085,-0.2921536862850189,-0.2881252467632294,-0.241798147559166,-0.1149327084422112,0.02087466046214104,0.1224402636289597,0.2149113416671753,0.2648091018199921,0.2267525196075439,0.1044953763484955,-0.03012176975607872,-0.1316873729228973,-0.1943113505840302,-0.2111575603485107,-0.2162236422300339,-0.2262642234563828,-0.2069765329360962,-0.1837519407272339,-0.2130497097969055,-0.2399975657463074,-0.2175359427928925,-0.1756340265274048,-0.1666005402803421,-0.2003540098667145,-0.2252571135759354,-0.2201605290174484,-0.1814020276069641,-0.1948301643133163,-0.2760094106197357,-0.3339945673942566,-0.3714712858200073,-0.3613086342811584,-0.3232825696468353,-0.3079622685909271,-0.3129062652587891,-0.2945036292076111,-0.1138645559549332,0.1232337430119514,0.203894168138504,0.1633655875921249,0.1067537441849709,0.1217688545584679,0.1558580249547958,0.1755119413137436,0.2219611257314682,0.2579729557037354,0.2744224369525909,0.2740562260150909,0.2642597854137421,0.2633137106895447,0.2732322216033936,0.286843478679657,0.3005462884902954,0.3079317510128021,0.3003021478652954,0.2966704368591309,0.3065584301948547,0.3193456828594208,0.3356730937957764,0.3428144156932831,0.334665983915329,0.3167210817337036,0.2932523488998413,0.269356369972229,0.256630152463913,0.2763145864009857,0.3034150302410126,0.2749412655830383,0.1448408514261246,-0.0003051850944757462,-0.079348124563694,-0.1297036707401276,-0.1280861794948578,-0.1089815944433212,-0.1476485431194305,-0.2012390494346619,-0.2399975657463074,-0.2647785842418671,-0.2706686556339264,-0.2160405218601227,-0.04263435676693916,0.1266823261976242,0.1240577399730682,-0.04638813436031342,-0.2129581570625305,-0.2735068798065186,-0.3076570928096771,-0.3234046399593353,-0.3065889477729797,-0.2845850884914398,-0.2466505914926529,-0.1991027593612671,-0.1161229312419891,0.04339732229709625,0.191198468208313,0.2589190304279327,0.286690890789032,0.2982268631458282,0.3024994730949402,0.2964262962341309,0.2674337029457092,0.2226020097732544,0.208990752696991,0.2468947470188141,0.2801599204540253,0.2493362277746201,0.1656849831342697,0.06491287052631378,-0.005340739153325558,0.01278725545853376,0.08517716079950333,0.1652577221393585,0.2265388965606689,0.2458876371383667,0.2304452657699585,0.1277504861354828,-0.03817865625023842,-0.1485030651092529,-0.1820734292268753,-0.1917172819375992,-0.156163215637207,0.0162053294479847,0.1884212791919708,0.1439252942800522,-0.04919583722949028,-0.189092680811882,-0.1813714951276779,-0.0397961363196373,0.08633686602115631,0.04846339300274849,0.008209479041397572,0.1165196672081947,0.2454298585653305,0.3097933828830719,0.3389690816402435,0.3709830045700073,0.4100466966629028,0.4568010568618774,0.4812158644199371,0.4387951195240021,0.3233130872249603,0.08456678688526154,-0.09918515384197235,-0.143375962972641,-0.188940092921257,-0.2198858559131622,-0.2060304582118988,-0.1389507800340652,-0.09762871265411377,-0.1077303364872932,-0.09897152334451675,-0.1130710765719414,-0.1745658814907074,-0.2260811179876328,-0.251564085483551,-0.2656636238098145,-0.2799768149852753,-0.3033539950847626,-0.299539178609848,-0.2729270160198212,-0.2639850974082947,-0.2553483545780182,-0.2479934096336365,-0.2664571106433868,-0.2986541390419006,-0.3115634620189667,-0.2983184158802032,-0.2840357720851898,-0.2863246500492096,-0.2951444983482361,-0.2876980006694794,-0.2335276305675507,-0.1377605497837067,-0.09955137968063354,-0.1495712101459503,-0.1812494248151779,-0.09137241542339325,0.07666249573230743,0.1743827611207962,0.2248909026384354,0.1815851330757141,-0.0712302029132843,-0.2782677710056305,-0.3260292410850525,-0.3088778257369995,-0.143406480550766,0.1035798192024231,0.2405468970537186,0.2718283534049988,0.2356029003858566,0.1198461875319481,0.0877407118678093,0.1578722447156906,0.1876583099365234,0.2196417152881622,0.2688375413417816,0.2562639117240906,0.1237220391631126,0.02243110537528992,0.1087984889745712,0.2327036410570145,0.2765892446041107,0.2840357720851898,0.2056642323732376,-0.03045747242867947,-0.2237922251224518,-0.2655110359191895,-0.2645954787731171,-0.2581255435943604,-0.2668233215808868,-0.3123264312744141,-0.3811151385307312,-0.4226203262805939,-0.3973815143108368,-0.3068025708198547,-0.1944639384746552,-0.1497848480939865,-0.2208929657936096,-0.2974334061145782,-0.3282570838928223,-0.2208624482154846,0.04129154235124588,0.1973021626472473,0.2284310460090637,0.2600176930427551,0.2880947291851044,0.3338114619255066,0.3970153033733368,0.382366418838501,0.3294472992420197,0.3138828575611115,0.3534348607063293,0.4467299282550812,0.4539628326892853,0.4398022294044495,0.4393139481544495,0.3722647726535797,0.3261207938194275,0.317087322473526,0.3273110091686249,0.3467207849025726,0.2862941324710846,0.06521805375814438,-0.1481063216924667,-0.2200689762830734,-0.2450636327266693,-0.2551347315311432,-0.2529679238796234,-0.2428662925958633,-0.2249214202165604,-0.2211371213197708,-0.1945249736309052,-0.1600695848464966,-0.20676289498806,-0.2649006545543671,-0.2894375324249268,-0.3031098246574402,-0.2897427380084991,-0.2605670392513275,-0.2304147481918335,-0.2472609579563141,-0.2919705808162689,-0.347331166267395,-0.3611865639686584,-0.317056804895401,-0.2258369773626328,-0.06292916834354401,-0.07498397678136826,-0.2249824553728104,-0.2927030324935913,-0.3235877454280853,-0.3337199091911316,-0.2653279304504395,-0.01690725423395634,0.2132328301668167,0.2722251117229462,0.1415448486804962,-0.1396526992321014,-0.2733237743377686,-0.2714621424674988,-0.2533036172389984,-0.2294991910457611,-0.2169560790061951,-0.1894589066505432,-0.191259503364563,-0.2443922311067581,-0.2988067269325256,-0.3258766531944275,-0.3356730937957764,-0.3342692255973816,-0.3403118848800659,-0.3617053627967834,-0.3818781077861786,-0.3976866900920868,-0.4053773581981659,-0.395184189081192,-0.3866695165634155,-0.3151341378688812,-0.09631641954183578,0.113376259803772,0.17380291223526,0.2001403868198395,0.2099673449993134,0.2555620074272156,0.400402843952179,0.4293954372406006,0.4070558845996857,0.3893856704235077,0.3097628653049469,0.282509833574295,0.3033845126628876,0.3455305695533752,0.3541673123836517,0.3079012334346771,0.2617267370223999,0.2157963812351227,0.1962035000324249,0.2325205206871033,0.2805566489696503,0.3180944323539734,0.3226416707038879,0.2917264401912689,0.2736899852752686,0.2788476347923279,0.2844935357570648,0.2078920900821686,0.06961271911859512,-0.01535081025213003,-0.03631702810525894,-0.02517777122557163,-0.1192358136177063,-0.2721335589885712,-0.3449201881885529,-0.3194067180156708,-0.09903256595134735,0.1164891496300697,0.1824091374874115,0.208868682384491,0.2269661575555801,0.2684408128261566,0.2963652312755585,0.2969756126403809,0.2851649522781372,0.2560808062553406,0.2503433227539062,0.2768944501876831,0.2935575544834137,0.2890408039093018,0.3003326654434204,0.3394268751144409,0.4113589823246002,0.4528336524963379,0.4074220955371857,0.3218176960945129,0.1019928604364395,-0.1354411393404007,-0.1280556619167328,0.07394634932279587,0.2579729557037354,0.3118991553783417,0.30454421043396,0.251777708530426,0.2113101631402969,0.2526627480983734,0.3122348785400391,0.347758412361145,0.3563646376132965,0.3084505796432495,0.2349620014429092,0.1849421709775925,0.1013214513659477,0.01757866144180298,0.003204443491995335,-0.01547288428992033,-0.08642841875553131,-0.1511276662349701,-0.1624805480241776,-0.1010467857122421,-0.02606280706822872,-0.03759880363941193,-0.1140171512961388,-0.1903744637966156,-0.2351756393909454,-0.2552262842655182,-0.1008636727929115,0.1825617253780365,0.3071688115596771,0.2648091018199921,0.06088442727923393,-0.1236915215849876,-0.09686575084924698,0.03506576642394066,0.1645558029413223,0.2062440812587738,0.1251258850097656,-0.01281777396798134,-0.1073030829429626,-0.1279641091823578,-0.1368755102157593,-0.1796624660491943,-0.2237617075443268,-0.3125095367431641,-0.395428329706192,-0.3950010538101196,-0.3733329176902771,-0.3319193124771118,-0.2934660017490387,-0.2750023007392883,-0.251777708530426,-0.2481459975242615,-0.2722861468791962,-0.2833948731422424,-0.2006286829710007,-0.04275643080472946,0.06720175594091415,0.04086428508162498,-0.09390545636415482,-0.1718192100524902,-0.128635510802269,-0.05609302222728729,-0.1109653040766716,-0.234321117401123,-0.2902005016803741,-0.3260902762413025,-0.3253578245639801,-0.3024079203605652,-0.2929471731185913,-0.2722556293010712,-0.2258674949407578,-0.2146672010421753,-0.2086550444364548,-0.03396710008382797,0.1672109067440033,0.1910153478384018,0.1467024683952332,0.1582079529762268,0.2094180136919022,0.1627857238054276,-0.01818903163075447,-0.145939514040947,-0.1078524142503738,-0.01150547806173563,0.001159703359007835,-0.05899227783083916,-0.09421063959598541,-0.1187780424952507,-0.1732840985059738,-0.2142094224691391,-0.1776482462882996,0.01498458813875914,0.2231513410806656]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>7</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>32+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>64+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>delay</key><value>32+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>140</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>140</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0</value></param>
<param><key>high</key><value>100</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>100</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_0</value></param>
<param><key>high</key><value>100</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>100</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1</value></param>
<param><key>high</key><value>40</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>40</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0_1_0</value></param>
<param><key>high</key><value>45</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>45</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1</value></param>
<param><key>high</key><value>100</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>100</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2</value></param>
<param><key>high</key><value>40</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>40</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>(25*[0]+1*[1]+74*[0])</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>(25*[0]+10*[1]+15*[0]+50*[0])</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/ben/Desktop/SENIOR_DESIGN/sounds/crowd_shots/wav/ar15_crowd_shot.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>desert_eagle_357</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[0.06451612710952759,0.1043122634291649,0.1589404046535492,0.1445966958999634,0.1069978922605515,0.06976531445980072,0.02673421427607536,-0.01477095857262611,-0.04016235843300819,-0.01770073547959328,0.01831110566854477,0.03540147095918655,0.01507614366710186,-0.02313303016126156,-0.06384472548961639,-0.1326944828033447,-0.1790826171636581,-0.188787505030632,-0.2222968190908432,-0.221503347158432,-0.1546067744493484,-0.1335490047931671,-0.1734672039747238,-0.2395092695951462,-0.2865077555179596,-0.2799768149852753,-0.2425000816583633,-0.186468094587326,-0.1668141782283783,-0.1605883985757828,-0.1342204064130783,-0.1160313710570335,-0.09411908686161041,-0.0313119925558567,0.05133213475346565,0.08606220036745071,0.06646931171417236,0.03222754597663879,0.0240485854446888,0.01220740377902985,-0.01855525374412537,-0.02893154695630074,-0.03460799157619476,-0.0319223627448082,-0.01702932827174664,-0.02014221623539925,-0.01013214513659477,-0.008301034569740295,-0.03003021329641342,-0.004211554303765297,0.01470992155373096,-0.05725272372364998,-0.1115756705403328,-0.06994842737913132,-0.03601184114813805,-0.06073183566331863,-0.1005279719829559,-0.1355632245540619,-0.1419110745191574,-0.09796441346406937,-0.05658131837844849,-0.03442487865686417,-0.0009155552834272385,-0.001281777396798134,-0.01068147830665112,-0.008972441777586937,0.00158696249127388,0.05505539104342461,0.07690664380788803,0.07483138889074326,0.09082308411598206,0.06237983331084251,0.004089480265974998,-0.01019318215548992,0.01324503310024738,0.04437391459941864,0.03796502575278282,0.001037629321217537,0.004089480265974998,-0.007019257172942162,-0.03888058289885521,-0.05102694779634476,-0.05658131837844849,-0.04058961942791939,-0.01342814415693283,-0.007873775437474251,-0.03369243443012238,-0.06744590401649475,-0.07415997982025146,-0.09088411927223206,-0.1406903266906738,-0.1719412803649902,-0.193853572010994,-0.1977599412202835,-0.2128971219062805,-0.257209986448288,-0.2420728206634521,-0.1766411364078522,-0.1387371420860291,-0.1515549123287201,-0.1523483991622925,-0.1102328598499298,-0.09796441346406937,-0.124698631465435,-0.1110873743891716,-0.07568590342998505,-0.06750694662332535,-0.06677450239658356,-0.04181035980582237,0.01910458691418171,0.03894161805510521,0.01495406962931156,-0.0008545182645320892,0.01098666340112686,0.04669332131743431,0.05413983762264252,0.03228858485817909,-0.006775109097361565,-0.04046754539012909,-0.03466902673244476,-0.005920590832829475,0.03070162050426006,0.06115909293293953,0.07483138889074326,0.09900204837322235,0.1228675171732903,0.1351359635591507,0.1249427795410156,0.1015655994415283,0.09283730387687683,0.08990752696990967,0.09784234315156937,0.1195715218782425,0.143620103597641,0.158757284283638,0.1909848302602768,0.2321237772703171,0.2326731234788895,0.2034974247217178,0.1803643852472305,0.1638844013214111,0.1352580338716507,0.1166417449712753,0.08142338693141937,0.003418073058128357,-0.04321420937776566,-0.039674062281847,-0.02325510419905186,-0.02056947536766529,-0.04077272862195969,-0.07672353088855743,-0.08624530583620071,-0.08801538497209549,-0.0871608629822731,-0.07495345920324326,-0.1270790696144104,-0.1961729824542999,-0.2396923750638962,-0.2713095545768738,-0.2738730907440186,-0.2378002256155014,-0.1951353549957275,-0.1657765507698059,-0.1349528431892395,-0.1540574431419373,-0.1964171230792999,-0.1908017247915268,-0.1777397990226746,-0.1829889863729477,-0.1850642412900925,-0.1772515028715134,-0.1408123970031738,-0.109500415623188,-0.09826960414648056,-0.09295938163995743,-0.09088411927223206,-0.05011139437556267,-0.01422162540256977,0.01629688404500484,0.04425184056162834,-0.01025421917438507,-0.07415997982025146,-0.09765923023223877,-0.1275063306093216,-0.1384930014610291,-0.1332438141107559,-0.123538926243782,-0.1339152157306671,-0.1986144632101059,-0.2290719300508499,-0.1757866144180298,-0.1139561161398888,-0.06012146547436714,-0.02710043638944626,-0.04870754107832909,-0.05072176456451416,0.01251258887350559,0.07470931112766266,0.1398968547582626,0.2196111977100372,0.2711264491081238,0.3026825785636902,0.2924894094467163,0.2534867525100708,0.2047791928052902,0.1794488430023193,0.1907406896352768,0.1491134315729141,0.08496353030204773,0.04846339300274849,0.04168828576803207,0.03283791616559029,-0.005432294681668282,-0.02716147340834141,-0.03765984252095222,-0.03320413827896118,-0.002502517774701118,0.004089480265974998,0.01208532974123955,0.04437391459941864,0.02423169650137424,-0.04297006130218506,-0.07837153226137161,-0.03875850886106491,-0.007751701399683952,-0.02374340035021305,-0.02166814170777798,-0.05456709489226341,-0.07263405621051788,-0.01434369944036007,0.0120242927223444,-0.01477095857262611,-0.05706961452960968,-0.0714743509888649,-0.08252204954624176,-0.1332438141107559,-0.1240882575511932,-0.01660206913948059,0.06640827655792236,0.07477034628391266,0.08087404817342758,0.06939908862113953,0.06701865047216415,0.1277504861354828,0.1444135904312134,0.08069094270467758,0.04602191224694252,0.008117923513054848,-0.06402783095836639,-0.06866664439439774,-0.01275673694908619,0.04535050690174103,0.05175939202308655,0.04095584154129028,0.04498428478837013,0.006408886983990669,-0.04370250552892685,-0.0277718435972929,-0.001647999510169029,0.003357036039233208,0.06903287023305893,0.1530198007822037,0.2016052752733231,0.1973326802253723,0.1488082557916641,0.1021149307489395,0.07348857074975967,0.06915494054555893,0.08923612534999847,0.1206091493368149,0.1427655816078186,0.1536301821470261,0.1115146353840828,0.03387554734945297,-0.01416058838367462,-0.0399182103574276,-0.08990752696990967,-0.08655049651861191,-0.00714133121073246,0.03027436137199402,0.04181035980582237,0.0120242927223444,-0.02905362099409103,-0.05059969052672386,-0.06488235294818878,-0.03009125031530857,-0.02520828880369663,-0.07702872157096863,-0.1024811565876007,-0.08099612593650818,-0.06927701830863953,-0.07977538555860519,-0.1280556619167328,-0.2236396372318268,-0.28211310505867,-0.2927945852279663,-0.2774132490158081,-0.2258980125188828,-0.1361735910177231,-0.06952116638422012,-0.08215583115816116,-0.07452619820833206,-0.02826013974845409,-0.02490310370922089,-0.02209540084004402,0.01678518019616604,0.005310220643877983,-0.004516739398241043,0.08014160394668579,0.1527756601572037,0.1934873461723328,0.1868343204259872,0.1069368571043015,0.06103701889514923,0.05383465066552162,0.04815820977091789,0.03625598922371864,0.03747672960162163,0.05218665301799774,0.04858546704053879,0.0121463667601347,-0.01690725423395634,-0.0200811792165041,-0.09411908686161041,-0.1512497365474701,-0.1303750723600388,-0.09076204895973206,-0.04620502516627312,-0.02746665850281715,-0.02435377053916454,-0.02240058593451977,0.01709036529064178,0.05310220643877983,0.0199591051787138,-0.0239265114068985,-0.05963316932320595,-0.06939908862113953,-0.002563554793596268,0.001403851434588432,-0.0877101942896843,-0.1322061866521835,-0.1355021893978119,-0.1060823425650597,-0.09411908686161041,-0.1113925576210022,-0.1025421917438507,-0.08087404817342758,-0.06018250063061714,-0.06036561354994774,-0.03393658250570297,0.05041657760739326,0.08557390421628952,0.01129184849560261,-0.01806695759296417,0.06018250063061714,0.1033967137336731,0.08398693799972534,0.09125034511089325,0.1168248578906059,0.07983642071485519,0.04449598863720894,0.02429273352026939,-0.01055940426886082,-0.01196325570344925,-0.008972441777586937,-0.01446577347815037,0.01116977445781231,0.05444502085447311,0.0471816174685955,0.04547258093953133,0.1160313710570335,0.1854304671287537,0.1902523934841156,0.1872005313634872,0.1756645441055298,0.128482922911644,0.1160924136638641,0.09363079071044922,0.05133213475346565,0.0474257655441761,0.0472426526248455,0.01141392253339291,-0.03686635941267014,-0.06140324100852013,-0.04370250552892685,0.03839228674769402,0.1378826200962067,0.1681569814682007,0.1473433673381805,0.143314927816391,0.1221961155533791,0.09228797256946564,0.1014435291290283,0.09131138026714325,0.05713064968585968,0.07196264714002609,0.1124301925301552,0.1059602648019791,0.0953398272395134,0.0949736014008522,0.07739493995904922,0.04156621173024178,0.01641895808279514,0.06128116697072983,0.1220740377902985,0.1427045464515686,0.1657155007123947,0.1900082379579544,0.1696218699216843,0.1359904855489731,0.0952787846326828,0.05066072568297386,0.03625598922371864,0.02209540084004402,-0.006591998040676117,-0.03735465556383133,-0.08960234373807907,-0.1797540187835693,-0.2526932656764984,-0.2703329622745514,-0.241523489356041,-0.1794488430023193,-0.1464278101921082,-0.1417279541492462,-0.143436998128891,-0.1992858648300171,-0.2533036172389984,-0.2051454186439514,-0.1448408514261246,-0.13104647397995,-0.0794702023267746,-0.04840235784649849,-0.07593005150556564,-0.08563493937253952,-0.02984710223972797,0.012268440797925,-0.05633717030286789,-0.1041901931166649,-0.04034547135233879,0.04193243384361267,0.1055330038070679,0.1196325570344925,0.0632343515753746,-0.008789330720901489,-0.0239265114068985,0.008301034569740295,0.0003662221133708954,-0.01641895808279514,-0.0319223627448082,-0.08612323552370071,-0.1202429309487343,-0.08008056879043579,-0.06732383370399475,-0.1054109334945679,-0.1007721200585365,-0.1049836724996567,-0.09912411868572235,-0.09088411927223206,-0.08044679462909698,-0.03314310312271118,-0.05175939202308655,-0.1232337430119514,-0.1204870790243149,-0.09192175418138504,-0.1013824865221977,-0.06036561354994774,-0.04669332131743431,-0.07495345920324326,-0.09094516187906265,-0.1118808537721634,-0.08148442208766937,-0.03021332435309887,0.005493331700563431,0.05371257662773132,0.09070101380348206,0.06738486886024475,-0.00952177494764328,-0.02923673205077648,0.03570665791630745,0.07446516305208206,0.1140171512961388,0.1696829199790955,0.1660817265510559,0.09875790029764175,0.06402783095836639,0.06732383370399475,0.07428205013275146,0.08563493937253952,0.06073183566331863,0.05383465066552162,0.03784295171499252,0.02978606522083282,0.02270577102899551,-0.02179021574556828,-0.02044740132987499,-0.01892147585749626,-0.01110873743891716,0.04089480265974998,0.07342753559350967,0.06067079678177834,0.02618488110601902,-0.01141392253339291,-0.007812738418579102,0.02130191959440708,-0.005737479776144028,-0.06781212985515594,-0.1344035118818283,-0.1513718068599701,-0.1187780424952507,-0.09186071157455444,-0.06530961394309998,-0.08203375339508057,-0.1256141811609268,-0.1467940360307693,-0.1277504861354828,-0.1298867762088776,-0.1423993706703186,-0.09955137968063354,-0.08362071961164474,-0.0710470899939537,-0.0473036915063858,-0.001831110566854477,0.02795495465397835,-0.02172917872667313,-0.07641834765672684,-0.1036408618092537,-0.06726279854774475,-0.001403851434588432,-0.02172917872667313,-0.06213568523526192,-0.06018250063061714,-0.1138950809836388,-0.1637012809514999,-0.1694387644529343,-0.1853694319725037,-0.1497848480939865,-0.07574693858623505,-0.0473647266626358,-0.0121463667601347,0.05957213044166565,0.09619434177875519,0.09613330662250519,0.09253212064504623,0.1003448590636253,0.1500289887189865,0.2176580131053925,0.2466505914926529,0.206366166472435,0.1255531460046768,0.09863582253456116,0.1129795238375664,0.1212805584073067,0.1047395244240761,0.08337657153606415,0.09332560002803802,0.07428205013275146,0.08838160336017609,0.1115756705403328,0.07623523473739624,0.04382457956671715,0.008362071588635445,-0.01446577347815037,-0.005920590832829475,-0.0004882961511611938,-0.0718405693769455,-0.128360852599144,-0.1113925576210022,-0.161259800195694,-0.2412793338298798,-0.2453688234090805,-0.2196722328662872,-0.239448219537735,-0.269783616065979,-0.2937101423740387,-0.3585314452648163,-0.4038819670677185,-0.3709830045700073,-0.2920010983943939,-0.2098452746868134,-0.1604052931070328,-0.1730399429798126,-0.2022156417369843,-0.1806085407733917,-0.1376384794712067,-0.1112704873085022,-0.06036561354994774,0.002746665850281715,0.09076204895973206,0.1472212970256805,0.04467909783124924,-0.0634174644947052,-0.08404797315597534,-0.1156651526689529,-0.1996520906686783,-0.2884609401226044,-0.3120822906494141,-0.3087252378463745,-0.236579492688179,-0.13080233335495,-0.06903287023305893,-0.0116580706089735,-0.001464888453483582,-0.002319406718015671,0.04351939633488655,0.07318338751792908,0.03906369209289551,-0.01043733023107052,-0.01690725423395634,0.04272591322660446,0.0950956791639328,0.1450239568948746,0.2200384587049484,0.2459181547164917,0.2799157798290253,0.3135471642017365,0.3030487895011902,0.2853480577468872,0.2909634709358215,0.2951139807701111,0.2487868964672089,0.2131412774324417,0.2185735702514648,0.2313913404941559,0.208807647228241,0.1694387644529343,0.1571703255176544,0.1007110849022865,0.04419080168008804,0.04858546704053879,0.03332621231675148,0.02826013974845409,-0.0115359965711832,-0.1079134494066238,-0.1696218699216843,-0.2205877900123596,-0.2271187454462051,-0.1875057220458984,-0.1400799602270126,-0.1010773032903671,-0.07470931112766266,-0.06042664870619774,-0.04065065458416939,-0.02075258642435074,-0.09619434177875519,-0.1735282391309738,-0.1759697198867798,-0.1618091315031052,-0.1386150717735291,-0.09088411927223206,-0.03759880363941193,-0.0632953867316246,-0.08471938222646713,-0.07403790205717087,-0.1304361075162888,-0.1572313606739044,-0.1501510739326477,-0.1521042585372925,-0.1048005595803261,-0.08624530583620071,-0.109622485935688,-0.06390576064586639,-0.03479110077023506,-0.1300088465213776,-0.1853083968162537,-0.1917783170938492,-0.2009949088096619,-0.1650440990924835,-0.1544846892356873,-0.1080355271697044,-0.06537064909934998,-0.03540147095918655,0.04608295112848282,0.07507553696632385,0.1092562675476074,0.2046571224927902,0.2255928218364716,0.1873226165771484,0.1947691291570663,0.1525315046310425,0.1195104867219925,0.1375164091587067,0.1005890071392059,0.09241005033254623,0.1366618871688843,0.1789605468511581,0.2251045256853104,0.2889492511749268,0.3446760475635529,0.2945036292076111,0.1535080969333649,0.05639820545911789,0.03326517716050148,-0.02935880608856678,-0.1212805584073067,-0.1026642695069313,-0.06811731308698654,-0.02319406718015671,0.01049836724996567,-0.03912473097443581,-0.08380382508039474,-0.1742606908082962,-0.193731501698494,-0.1622974276542664,-0.2109439373016357,-0.2038026005029678,-0.1630298793315887,-0.1564989238977432,-0.1225623339414597,-0.08990752696990967,-0.1110873743891716,-0.1013824865221977,-0.0317392498254776,0.02691732533276081,0.03534043580293655,-0.01379436627030373,-0.08801538497209549,-0.1198156699538231,-0.126163512468338,-0.143314927816391,-0.08069094270467758,0.01910458691418171,0.01641895808279514,-0.02294991910457611,0.002258369699120522,0.1136509329080582,0.221442312002182,0.2540360689163208,0.2398144453763962,0.2223578542470932,0.2556840777397156,0.3122653961181641,0.3626209199428558,0.3631092309951782,0.2245551943778992,0.1185949295759201,0.1220130026340485,0.04596087709069252,-0.01440473645925522,-0.04913480207324028,-0.06518753618001938,-0.0202032532542944,-0.01275673694908619,-0.06939908862113953,-0.110721156001091,-0.05743583664298058,-0.03729362040758133,-0.09649952501058578,-0.1501510739326477,-0.1376384794712067,-0.109622485935688,-0.1485641002655029,-0.2274849712848663,-0.2535477876663208,-0.2471999228000641,-0.2474440783262253,-0.2270577102899551,-0.2774742841720581,-0.2954802215099335,-0.2559282183647156,-0.2363963723182678,-0.1779839545488358,-0.1422772854566574,-0.1073641180992126,-0.07641834765672684,-0.09082308411598206,-0.05475020781159401,-0.03454695269465446,-0.02478102967143059,0.01007110811769962,-0.01452681049704552,-0.006286812946200371,0.04095584154129028,0.1227454468607903,0.1492965519428253,0.06671345978975296,0.04803613573312759,0.06506546586751938,0.03033539839088917,-0.01080355234444141,0.008911404758691788,0.04870754107832909,0.08148442208766937,0.09826960414648056,0.07257301360368729,0.0636616125702858,0.07489242404699326,0.06946013122797012,0.08404797315597534,0.1316568553447723,0.1403241008520126,0.1339762508869171,0.143375962972641,0.1975768357515335,0.3331400454044342,0.4108401834964752,0.4542374908924103,0.4766380786895752,0.4237189888954163,0.3585924804210663,0.2540360689163208,0.1723075062036514,0.1353801041841507,0.07257301360368729,-0.02038636431097984,-0.07696767896413803,-0.06622516363859177,-0.05609302222728729,-0.05127109587192535,-0.01483199559152126,0.007080294191837311,-0.03814813867211342,-0.1267738938331604,-0.1539353579282761,-0.08777123689651489,-0.003295999020338058,0.05603198334574699,0.03888058289885521,0.02557451091706753,0.04559465497732162,0.03363139927387238,-0.02783288061618805,-0.1079744845628738,-0.08966337889432907,-0.0556047260761261,-0.04309213533997536,-0.06872768700122833,-0.1524704694747925,-0.1162755191326141,-0.08105716109275818,-0.09259315580129623,-0.05987731739878654,-0.02014221623539925,0.0157475508749485,0.01086458936333656,0.009643848985433578,0.0472426526248455,0.09015167504549026,0.05346842855215073,0.04101687669754028,0.1289712190628052,0.160893589258194,0.1700491309165955,0.2103335708379745,0.204046756029129,0.2121036350727081,0.2219306081533432,0.2141789048910141,0.2666707336902618,0.2712485194206238,0.1716971397399902,0.06530961394309998,0.04968413338065147,0.09625537693500519,0.09375286102294922,-0.00555436871945858,-0.0948515310883522,-0.1155430749058723,-0.1540574431419373,-0.160954624414444,-0.128177747130394,-0.1318399608135223,-0.158635213971138,-0.1507614403963089,-0.1544846892356873,-0.1662648469209671,-0.1883602440357208,-0.1770683974027634,-0.09662160277366638,-0.1521042585372925,-0.1837824583053589,-0.09698782116174698,-0.03509628772735596,0.03485213965177536,0.03485213965177536,-0.0316171757876873,-0.08954130858182907,-0.1207312270998955,-0.07770012319087982,-0.02105777151882648,-0.05432294681668282,-0.06274605542421341,0.05121006071567535,0.1303750723600388,0.1151158213615417,0.1048616021871567,0.1034577488899231,0.05963316932320595,0.02893154695630074,0.007385479286313057,-0.09863582253456116,-0.1347087025642395,-0.03778191655874252,-0.008789330720901489,-0.00079348124563694,0.03839228674769402,-0.008484145626425743,-0.03863643482327461,0.01391644030809402,0.004516739398241043,-0.06457716971635818,-0.1213415935635567,-0.1341593712568283,-0.08069094270467758,-0.06714072078466415,-0.0551164299249649,0.02911465801298618,0.09424115717411041,0.1171300411224365,0.1384930014610291,0.1664479523897171,0.1346476674079895,0.08056886494159698,0.09204382449388504,0.1051667854189873,0.05786309391260147,-0.01324503310024738,-0.07403790205717087,-0.1066927090287209,-0.1315347701311111,-0.1878109127283096,-0.2453688234090805,-0.3065279126167297,-0.3325907289981842,-0.2796105742454529,-0.2501907348632812,-0.2809534072875977,-0.2128360867500305,-0.08905301243066788,-0.04712057858705521,-0.02941984310746193,-0.06671345978975296,-0.09356974810361862,-0.03875850886106491,0.0238044373691082,0.08642841875553131,0.1364177316427231,0.08050782978534698,0.006225775927305222,-0.05603198334574699,-0.141178622841835,-0.1281166970729828,-0.1406903266906738,-0.1538132876157761,-0.08380382508039474,-0.03357036039233208,-0.007812738418579102,0.008789330720901489,0.02874843589961529,-0.01049836724996567,-0.07043672353029251,-0.06427197903394699,-0.1040681153535843,-0.1511887013912201,-0.04412976652383804,0.04229865595698357,0.01617481000721455,0.008911404758691788,0.02819910272955894,0.06476027518510818,0.05438398569822311,-0.008301034569740295,0.01098666340112686,0.05468916893005371,0.07037568092346191,0.1068147867918015,0.08166753500699997,0.05993835255503654,0.1035798192024231,0.128421887755394,0.1226233690977097,0.1055330038070679,0.07629627734422684,0.05304117128252983,0.04834131896495819,0.04315317422151566,0.08246101438999176,0.1574755162000656,0.1185338944196701,0.002197332680225372,-0.02642902918159962,0.05005035549402237,0.1425214409828186,0.1118808537721634,0.03338725119829178,0.02258369699120522,0.003601184114813805,-0.06457716971635818,-0.110904261469841,-0.01098666340112686,0.1169469282031059,0.09460738301277161,0.0472426526248455,0.0313119925558567,-0.01147495955228806,-0.04425184056162834,-0.06091494485735893,-0.06860560923814774,-0.04596087709069252,-0.04632709920406342,-0.1342814415693283,-0.1999572813510895,-0.1931821703910828,-0.2505569756031036,-0.317392498254776,-0.352183610200882,-0.3703115880489349,-0.3265480399131775,-0.2882167994976044,-0.2157048285007477,-0.1892758011817932,-0.1604052931070328,-0.07617419958114624,-0.04174932092428207,0.01446577347815037,0.05291909724473953,0.08423108607530594,0.09424115717411041,0.05871761217713356,0.03778191655874252,0.03289895504713058,-0.03454695269465446,-0.1154210045933723,-0.1508224755525589,-0.1118808537721634,-0.0002441480755805969,0.01287881098687649,-0.06555376201868057,-0.2081972658634186,-0.2206488251686096,-0.09863582253456116,-0.08203375339508057,-0.109622485935688,-0.1366618871688843,-0.1118808537721634,-0.07379375398159027,-0.08490249514579773,-0.02081362344324589,0.05316324532032013,0.02240058593451977,-0.05786309391260147,-0.1164586320519447,-0.05468916893005371,-0.008545182645320892,-0.08954130858182907,-0.176152840256691,-0.2222968190908432,-0.1735282391309738,-0.007568590342998505,0.1231116652488708,0.08630634844303131,0.02581865899264812,-0.02325510419905186,-0.1173131540417671,-0.1471602469682693,-0.173833429813385,-0.1933042407035828,-0.1523483991622925,-0.1159703359007835,-0.03228858485817909,0.003723258152604103,-0.0713522732257843,-0.1213415935635567,-0.1453901827335358,-0.1168858930468559,-0.0870998278260231,-0.0634784996509552,-0.04449598863720894,-0.1640675067901611,-0.2645954787731171,-0.2856532633304596,-0.2436597794294357,-0.1507004052400589,-0.07977538555860519,-0.02899258397519588,-0.03350932523608208,-0.06158635392785072,-0.07770012319087982,-0.02264473401010036,0.07190161198377609,0.1078524142503738,0.1374553740024567,0.1766411364078522,0.1676686853170395,0.1375164091587067,0.1187780424952507,0.1158482655882835,0.1269569993019104,0.1529587656259537,0.1206091493368149,0.09045686572790146,0.1319009959697723,0.1038239672780037,0.05835139006376266,0.09796441346406937,0.1512497365474701,0.08862575143575668,0.008423108607530594,0.03265480697154999,0.02563554793596268,0.001831110566854477,0.04644917324185371,0.1101107820868492,0.1953184604644775,0.2535477876663208,0.2125919312238693,0.1466109156608582,0.08648945391178131,0.08355967700481415,0.09369182586669922,0.03460799157619476,-0.01666310615837574,-0.08417005091905594,-0.09967344999313354,-0.003051850944757462,0.1183507815003395,0.2167424559593201,0.2003845274448395,0.1431318074464798,0.1503952145576477,0.1043122634291649,0.03118991665542126,0.04876857995986938,0.07776116579771042,0.02862636186182499,-0.02624591812491417,-0.01123081147670746,-0.04620502516627312,-0.1226844117045403,-0.1151768565177917,-0.09222693741321564,-0.09045686572790146,-0.1035187840461731,-0.1187169998884201,-0.1002227887511253,-0.08191168308258057,-0.09002960473299026,-0.1114536002278328,-0.1074251532554626,-0.1517990678548813,-0.2436597794294357,-0.2489700019359589,-0.2503128051757812,-0.2388378530740738,-0.2675862908363342,-0.3569445013999939,-0.3159886598587036,-0.3061617016792297,-0.3574327826499939,-0.3256935477256775,-0.2549516260623932,-0.1718192100524902,-0.09930723160505295,-0.06079287081956863,-0.04101687669754028,-0.04907376319169998,-0.1356242597103119,-0.2403027415275574,-0.304940938949585,-0.2832117676734924,-0.2299264520406723,-0.2359691113233566,-0.269661545753479,-0.305063009262085,-0.287545382976532,-0.2160100042819977,-0.0875270888209343,0.03302102908492088,0.08978545665740967,0.09204382449388504,0.08404797315597534,0.06231879815459251,-0.01129184849560261,0.008423108607530594,0.04272591322660446,-0.01489303261041641,-0.04895168915390968,-0.1254310756921768,-0.2009949088096619,-0.1619922518730164,-0.2284005284309387,-0.3682973682880402,-0.3861812055110931,-0.3579821288585663,-0.3064668774604797,-0.299386590719223,-0.3520004749298096,-0.4108401834964752,-0.4620502293109894,-0.5092929005622864,-0.5328531861305237,-0.522171676158905,-0.5139316916465759,-0.4376964569091797,-0.3964964747428894,-0.3736686408519745,-0.3370464146137238,-0.34797203540802,-0.2938932478427887,-0.2404248118400574,-0.1550340354442596,-0.03808709979057312,-0.01403851434588432,0.04467909783124924,0.1479537338018417,0.2003845274448395,0.2071596384048462,0.1947691291570663,0.2251655608415604,0.3532212376594543,0.4162114262580872,0.2989593148231506,0.2254707515239716,0.241706594824791,0.2222968190908432,0.1672414392232895,0.1015045642852783,0.07550279051065445,0.07202368229627609,0.09558397531509399,0.1620532870292664,0.1104770079255104,-0.03735465556383133,-0.1414227783679962,-0.1336710751056671,-0.02630695514380932,0.05859553813934326,0.09881893545389175,0.09369182586669922,0.009399700909852982,-0.05676442757248878,-0.009399700909852982,0.03717154636979103,0.04290902614593506,0.08783227205276489,0.1506393700838089,0.1630298793315887,0.09582812339067459,0.02075258642435074,0.004089480265974998,0.06274605542421341,0.1208532974123955,0.1491744816303253,0.2511062920093536,0.3260597586631775,0.2982268631458282,0.2435377091169357,0.2074648290872574,0.1613818854093552,0.08484145998954773,0.02349925227463245,-0.01647999510169029,-0.04974517226219177,-0.1344035118818283,-0.2168034911155701,-0.234504222869873,-0.2229682356119156,-0.2616046667098999,-0.3505356013774872,-0.3010956048965454,-0.1166417449712753,-0.01519821770489216,0.02911465801298618,0.08636738359928131,0.113345742225647,0.1217688545584679,0.08294931054115295,0.006164738908410072,0.0555436871945858,0.2200384587049484,0.3040864169597626,0.3400372266769409,0.3871577978134155,0.4414197206497192,0.4712668359279633,0.3944822549819946,0.2965178489685059,0.2545854151248932,0.2208929657936096,0.2627033293247223,0.4096804857254028,0.5128940939903259,0.4886623620986938,0.3701895177364349,0.1992248296737671,0.1143833771348,0.1181066334247589,0.113284707069397,0.1748100221157074,0.241645559668541,0.1967833489179611,0.1825006902217865,0.2493362277746201,0.2579424381256104,0.28254035115242,0.3535874485969543,0.3768425583839417,0.4317758679389954,0.4621112644672394,0.3306375443935394,0.2061220109462738,0.1785332858562469,0.1116367056965828,0.02618488110601902,0.06445509195327759,0.1511276662349701,0.1964781582355499,0.1314737349748611,-0.01330607011914253,-0.005920590832829475,0.09710989892482758,0.1758476495742798,0.2546464502811432,0.3389385640621185,0.2795495390892029,0.1441083997488022,0.1450849920511246,0.239265114068985,0.3733634352684021,0.4836573302745819,0.539506196975708,0.5069124698638916,0.4713278710842133,0.4378795623779297,0.3015839159488678,0.156315803527832,0.09692678600549698,0.1955626159906387,0.2436597794294357,0.08001953363418579,-0.02844325080513954,-0.06683553755283356,-0.06189153715968132,0.02002014219760895,0.004394665360450745,-0.07757805287837982,-0.1685842424631119,-0.1601001024246216,-0.1347087025642395,-0.2848597764968872,-0.3703726232051849,-0.3617663979530334,-0.3852046132087708,-0.4380626976490021,-0.4397106766700745,-0.4522232711315155,-0.5446333289146423,-0.4975127279758453,-0.4955595433712006,-0.521805465221405,-0.4859767556190491,-0.5080111026763916,-0.5161900520324707,-0.5794854760169983,-0.4727927446365356,-0.2728354632854462,-0.2018494158983231,-0.158574178814888,-0.08618427067995071,-0.06952116638422012,-0.09784234315156937,0.006653035059571266,0.01385540328919888,0.01116977445781231,0.06530961394309998,0.02179021574556828,0.06280709058046341,0.08178960531949997,-0.0008545182645320892,-0.1129795238375664,-0.251716673374176,-0.2978606522083282,-0.1710257232189178,-0.03735465556383133,0.03814813867211342,0.1176183372735977,0.1381267756223679,0.1398358047008514,0.1532029211521149,0.171330913901329,0.1835383176803589,0.2583697140216827,0.3718985617160797,0.3596301078796387,0.2683797776699066,0.1154210045933723,-0.02319406718015671,-0.1225012987852097,-0.2747276127338409,-0.3024384379386902,-0.2708822786808014,-0.3268532454967499,-0.364757239818573,-0.400646984577179,-0.4179204702377319,-0.5203405618667603,-0.5851619243621826,-0.4981841444969177,-0.521988570690155,-0.6248970031738281,-0.6333200931549072,-0.5658131837844849,-0.5128940939903259,-0.4381237328052521,-0.3973509967327118,-0.3675038814544678,-0.3306375443935394,-0.2898648083209991,-0.2137516438961029,-0.2337717860937119,-0.2202825993299484,-0.2281563729047775,-0.3251442015171051,-0.3532212376594543,-0.3794671595096588,-0.426099419593811,-0.3603625595569611,-0.2258980125188828,-0.1908627599477768,-0.2094790488481522,-0.3029267191886902,-0.3535874485969543,-0.3360698223114014,-0.3071993291378021,-0.1425824761390686,0.03912473097443581,0.2157658636569977,0.3932004868984222,0.4466078579425812,0.34730064868927,0.2855921983718872,0.352183610200882,0.3391827046871185,0.2919400632381439,0.2738730907440186,0.3190405070781708,0.4290291965007782,0.521866500377655,0.7037568092346191,0.7458113431930542,0.5645924210548401,0.4444715678691864,0.4193243086338043,0.4765770435333252,0.6101870536804199,0.6613971590995789,0.6053651571273804,0.4654072821140289,0.3309427201747894,0.400036633014679,0.4802392721176147,0.4165166318416595,0.3092745840549469,0.1683401018381119,0.1029694527387619,0.1243324056267738,0.01452681049704552,-0.1169469282031059,-0.1207922622561455,-0.1641895771026611,-0.2470168173313141,-0.2282784581184387,-0.1315347701311111,-0.1532639563083649,-0.3033539950847626,-0.3701895177364349,-0.4101687669754028,-0.5067293047904968,-0.4524063766002655,-0.3242286443710327,-0.3415631651878357,-0.3418073058128357,-0.3012787401676178,-0.3093966543674469,-0.2752159237861633,-0.2809534072875977,-0.3116550147533417,-0.3891109824180603,-0.5054475665092468,-0.4701071083545685,-0.3750114440917969,-0.2332224547863007,-0.09826960414648056,-0.07611316442489624,-0.107181005179882,-0.1430707722902298,-0.09088411927223206,-0.04693746939301491,-0.03741569444537163,-0.05645924434065819,-0.01739555038511753,0.1024811565876007,0.1113925576210022,0.08642841875553131,-0.04199346899986267,-0.1876888275146484,-0.2807092368602753,-0.4365367591381073,-0.5872982144355774,-0.7600939869880676,-0.8171635866165161,-0.6559038162231445,-0.4459975063800812,-0.2674031853675842,-0.1547288447618484,-0.1398358047008514,-0.09363079071044922,0.04345835745334625,0.209173858165741,0.3096407949924469,0.3384502828121185,0.4665669798851013,0.5847956538200378,0.5609301924705505,0.4799340665340424,0.3328348696231842,0.2337107509374619,0.2802819907665253,0.34809410572052,0.3403424322605133,0.2890713214874268,0.2550736963748932,0.208990752696991,0.1923276484012604,0.2047791928052902,0.1057161167263985,0.06256294250488281,0.079348124563694,-0.06396679580211639,-0.1955626159906387,-0.1967833489179611,-0.257271021604538,-0.3435773849487305,-0.3381450772285461,-0.2945646643638611,-0.2438428848981857,-0.2606891095638275,-0.2396923750638962,-0.1658375859260559,-0.2038026005029678,-0.2599566578865051,-0.2721640765666962,-0.2624591886997223,-0.224005863070488,-0.2650227248668671,-0.2886440753936768,-0.2312082350254059,-0.2440870404243469,-0.1472212970256805,0.1209753751754761,0.28192999958992,0.2290719300508499,0.11444441229105,0.03106784261763096,-0.0709250196814537,-0.1898861676454544,-0.2165593504905701,-0.1076693013310432,-0.05645924434065819,-0.1881771236658096,-0.352916032075882,-0.4079714417457581,-0.3911862671375275,-0.299447625875473,-0.1701712161302567,-0.2166814208030701,-0.2687459886074066,-0.1657765507698059,-0.1339762508869171,-0.1148106306791306,-0.1001007109880447,-0.06732383370399475,0.07422101497650146,0.1274452954530716,0.2114932686090469,0.395153671503067,0.3786736726760864,0.2356029003858566,0.1741996556520462,0.2432935535907745,0.3270973861217499,0.3164769411087036,0.2718588709831238,0.1766411364078522,0.1014435291290283,0.1408123970031738,0.1583910584449768,0.07971435040235519,0.04699850454926491,0.08587908744812012,0.2199774235486984,0.3563341200351715,0.4505752623081207,0.5456709265708923,0.4882961511611938,0.3758049309253693,0.3543199002742767,0.3560289442539215,0.2701498568058014,0.2108829021453857,0.2221747487783432,0.145878478884697,0.1403241008520126,0.3136692345142365,0.382457971572876,0.1684621721506119,-0.1497848480939865,-0.2605060040950775,-0.1648609936237335,-0.0949125662446022,-0.04846339300274849,-0.05780205875635147,-0.1052278205752373,-0.07513657212257385,-0.05114902183413506,-0.08178960531949997,-0.1290322542190552,-0.1250648498535156,-0.1366618871688843,-0.2749717831611633,-0.383007287979126,-0.3751945495605469,-0.3977782428264618,-0.473952442407608,-0.5512253046035767,-0.5824152231216431,-0.555925190448761,-0.5241248607635498,-0.4719992578029633,-0.4817041456699371,-0.5891293287277222,-0.6634724140167236,-0.6632893085479736,-0.5431073904037476,-0.4216437339782715,-0.4772484600543976,-0.4879299402236938,-0.4673604667186737,-0.4885402917861938,-0.4093142449855804,-0.2413403689861298,-0.08301034569740295,-0.03796502575278282,0.008239997550845146,0.07428205013275146,0.1181676685810089,0.1367229223251343,0.2526932656764984,0.4086428284645081,0.4424573481082916,0.4896999895572662,0.5137485861778259,0.4950712621212006,0.4379405975341797,0.4705343842506409,0.5354777574539185,0.4251228272914886,0.3057954609394073,0.2646565139293671,0.2512283623218536,0.2266304492950439,0.2719809710979462,0.2720420062541962,0.2108829021453857,0.2885830402374268,0.395825058221817,0.4225592911243439,0.3338114619255066,0.1981872022151947,0.1087679713964462,0.1335490047931671,0.05896176025271416,-0.0397351011633873,-0.07635731250047684,-0.1879329830408096,-0.1815240979194641,-0.128543958067894,-0.004333628341555595,0.01580858789384365,-0.09076204895973206,-0.09729301184415817,-0.0394299142062664,0.009582811966538429,-0.1345866322517395,-0.2878505885601044,-0.286935031414032,-0.2752159237861633,-0.2981658279895782,-0.2311471849679947,-0.1926938742399216,-0.28235724568367,-0.2536088228225708,-0.2800988852977753,-0.3328348696231842,-0.334727019071579,-0.4389171898365021,-0.3497421145439148,-0.2007507532835007,-0.112063966691494,0.005859553813934326,-0.09350871294736862,-0.2182683795690536,-0.124637596309185,-0.06500442326068878,-0.1192052960395813,-0.08362071961164474,0.05401776358485222,0.171208843588829,0.2890102863311768,0.3698843419551849,0.3294167816638947,0.1877498775720596,0.04174932092428207,-0.001037629321217537,0.05804620683193207,0.1267738938331604,0.1988586038351059,0.2487868964672089,0.1567430645227432,0.007995849475264549,-0.1304361075162888,-0.1653492897748947,-0.08948027342557907,0.02710043638944626,0.1331217437982559,0.2070375680923462,0.219306007027626,0.08844263851642609,-0.07452619820833206,-0.1277504861354828,-0.08874782919883728,-0.13068026304245,-0.2257759273052216,-0.304269552230835,-0.426038384437561,-0.5438398122787476,-0.6299020648002625,-0.652668833732605,-0.6145207285881042,-0.6413159370422363,-0.6274605393409729,-0.4873805940151215,-0.34797203540802,-0.3673818111419678,-0.3935666978359222,-0.2681966722011566,-0.3119601905345917,-0.4166387021541595,-0.3843501210212708,-0.3180028796195984,-0.2293771207332611,-0.1347087025642395,-0.09369182586669922,-0.1099276691675186,-0.0875270888209343,-0.0557878352701664,-0.05359050258994102,0.01898251287639141,0.1982482373714447,0.2851039171218872,0.2918790280818939,0.2841273248195648,0.2209540158510208,0.1771294325590134,0.1666310578584671,0.1146885603666306,0.01324503310024738,0.1351359635591507,0.2965788841247559,0.3465071618556976,0.5242469310760498,0.5183263421058655,0.3864864110946655,0.3606677353382111,0.3196508586406708,0.3140965104103088,0.3851435780525208,0.4653462469577789,0.425489068031311,0.1970885396003723,-0.1534470617771149,-0.2901089489459991,-0.1386150717735291,0.04260383918881416,0.1406903266906738,0.03411969542503357,-0.08844263851642609,-0.03656117618083954,-0.0554216131567955,-0.1301919668912888,-0.07391583174467087,0.008911404758691788,0.00079348124563694,0.1199987828731537,0.3603015244007111,0.3945432901382446,0.4320810437202454,0.5496383309364319,0.5148472785949707,0.5124057531356812,0.5106356739997864,0.4141361713409424,0.2489089667797089,0.1429487019777298,0.1600390672683716,0.1455122530460358,0.1489303261041641,0.04181035980582237,-0.111941896378994,-0.2122257202863693,-0.3068330883979797,-0.3129978477954865,-0.3081148862838745,-0.334849089384079,-0.3142796158790588,-0.2359080761671066,-0.1757866144180298,-0.2109439373016357,-0.2750328183174133,-0.2497634887695312,-0.1050447076559067,0.05053865164518356,0.0194708090275526,0.08282723277807236,0.2105777114629745,0.3084200620651245,0.5200353860855103,0.5363933444023132,0.4558244645595551,0.4379405975341797,0.5046540498733521,0.6057924032211304,0.5671559572219849,0.4074831306934357,0.2636188864707947,0.09350871294736862,-0.1752372831106186,-0.3109835982322693,-0.2776573896408081,-0.2545854151248932,-0.3677480518817902,-0.4450819492340088,-0.443800151348114,-0.5718558430671692,-0.7029633522033691,-0.7077242136001587,-0.7148655652999878,-0.6655476689338684,-0.490859717130661,-0.3703115880489349,-0.2497024387121201,-0.08874782919883728,0.06109805777668953,0.05621509626507759,-0.008362071588635445,0.04077272862195969,0.05853450298309326,0.09259315580129623,0.1924497187137604,0.3803216516971588,0.5726493000984192,0.7093722224235535,0.7171849608421326,0.6298409700393677,0.5969420671463013,0.5426801443099976,0.4580828249454498,0.317270427942276,0.251838743686676,0.3052461445331573,0.3004852533340454,0.3706778287887573,0.5117954015731812,0.5016022324562073,0.3362529277801514,0.1666920930147171,0.1276894509792328,0.1720633506774902,0.2812585830688477,0.4057130515575409,0.4085207581520081,0.2963957786560059,0.1291543394327164,-0.004089480265974998,-0.005005035549402237,0.07794427126646042,0.1113315224647522,0.01300088502466679,-0.206366166472435,-0.3015839159488678,-0.1765190660953522,-0.1251258850097656,-0.2668538391590118,-0.3700674474239349,-0.461378812789917,-0.6631062030792236,-0.8289437294006348,-0.8359630107879639,-0.7397076487541199,-0.7936033010482788,-0.9057283401489258,-0.7725455760955811,-0.6507156491279602,-0.730368971824646,-0.808374285697937,-0.7766350507736206,-0.7384258508682251,-0.8193609714508057,-0.7874996066093445,-0.6199529767036438,-0.5875423550605774,-0.6609088182449341,-0.6440016031265259,-0.4953154027462006,-0.3798333704471588,-0.3878292143344879,-0.3890499472618103,-0.193792536854744,0.08819849044084549,0.2279122322797775,0.1931821703910828,0.2331003695726395,0.448255866765976,0.5501266717910767,0.5453047156333923,0.5407269597053528,0.4638813436031342,0.2887661457061768,0.1369670778512955,0.1361125558614731,0.1727958023548126,0.1608325392007828,0.1425824761390686,0.06714072078466415,0.06793420016765594,0.1959288269281387,0.2614825963973999,0.2229072004556656,0.1415448486804962,0.1718192100524902,0.2335886657238007,0.1904965341091156,0.005493331700563431,-0.171330913901329,-0.2700277864933014,-0.4195684790611267,-0.4530777931213379,-0.3848384022712708,-0.4234138131141663,-0.4490493535995483,-0.2760704457759857,-0.1791436523199081,-0.3533433079719543,-0.4765770435333252,-0.2896206676959991,-0.01635792106389999,0.007873775437474251,0.1243324056267738,0.4263435900211334,0.5857722759246826,0.6806848645210266,0.6251411437988281,0.5098422169685364,0.5454878211021423,0.6192205548286438,0.6880702972412109,0.6718955039978027,0.6395458579063416,0.5951109528541565,0.4503921568393707,0.3916745483875275,0.3153172433376312,0.1929990500211716,0.1101107820868492,0.07531968504190445,0.09961241483688354,0.04351939633488655,0.03277688100934029,0.05780205875635147,0.005127109587192535,-0.02514725178480148,-0.06158635392785072,-0.08197271823883057,-0.07049775868654251,-0.0790429413318634,-0.1243324056267738,-0.2879116237163544,-0.3519394397735596,-0.1942197978496552,-0.1034577488899231,-0.08935819566249847,-0.02978606522083282,0.0399792492389679,0.09418012201786041,0.06653035432100296,-0.01129184849560261,-0.06097598373889923,-0.1580248475074768,-0.1468550711870193,0.003723258152604103,0.0281380657106638,-0.07660146057605743,-0.2440260052680969,-0.4202398657798767,-0.4973296225070953,-0.4179815053939819,-0.334543913602829,-0.3975341022014618,-0.4182866811752319,-0.329721987247467,-0.3280739784240723,-0.3996703922748566,-0.4704123139381409,-0.4701071083545685,-0.4758445918560028,-0.6750694513320923,-0.747642457485199,-0.5943174362182617,-0.3974730670452118,-0.2022766768932343,-0.1544236540794373,-0.1513107717037201,-0.08239997923374176,0.1087069287896156,0.3318582773208618,0.2915128171443939,0.1384930014610291,0.1558885425329208,0.1782891303300858,0.1840876489877701,0.256355494260788,0.2423779964447021,0.1980040967464447,0.158452108502388,0.1558275073766708,0.2927945852279663,0.4060792922973633,0.3707998991012573,0.3415631651878357,0.3493148684501648,0.425489068031311,0.5269936323165894,0.4115726053714752,0.3639027178287506,0.4774926006793976,0.4580828249454498,0.4198126196861267,0.443067729473114,0.4178594350814819,0.2841883599758148,0.126041442155838,0.01403851434588432,-0.1139561161398888,-0.2227851152420044,-0.2525101602077484,-0.2710043787956238,-0.2940153181552887,-0.3497421145439148,-0.4211554229259491,-0.400524914264679,-0.1987975686788559,0.07196264714002609,0.08618427067995071,-0.05304117128252983,-0.2238227427005768,-0.3865474462509155,-0.395031601190567,-0.4231696426868439,-0.352244645357132,-0.2142399400472641,-0.3466292321681976,-0.3291726410388947,-0.1367839574813843,-0.28192999958992,-0.5055696368217468,-0.573686957359314,-0.5883358120918274,-0.47853022813797,-0.3458967804908752,-0.2738730907440186,-0.1856746077537537,-0.1600390672683716,-0.1446577310562134,0.0157475508749485,0.1278725564479828,0.1607104688882828,0.1358073651790619,0.02056947536766529,-0.0400402843952179,-0.07837153226137161,-0.03582873195409775,-0.00952177494764328,-0.001220740377902985,0.01922666095197201,-0.08954130858182907,-0.1021149307489395,-0.009399700909852982,0.1149937435984612,0.2285836338996887,0.1838435083627701,0.1054719686508179,0.0241706594824791,0.02148503065109253,0.1768242418766022,0.3709219694137573,0.5030061006546021,0.6201361417770386,0.7889034748077393,0.791161835193634,0.6317331194877625,0.5971251726150513,0.6024353504180908,0.5007476806640625,0.4531388282775879,0.47834712266922,0.4174321591854095,0.3021942675113678,0.2224799394607544,0.2149113416671753,0.1595507711172104,0.2326120734214783,0.3833735287189484,0.3874019682407379,0.5952940583229065,0.6671346426010132,0.4923245906829834,0.5292519927024841,0.6086001396179199,0.5857722759246826,0.6644489765167236,0.7155979871749878,0.5639210343360901,0.4801172018051147,0.5841242671012878,0.7035737037658691,0.6292916536331177,0.5079500675201416,0.4795678555965424,0.4406262338161469,0.4154789745807648,0.3061006367206573,0.2728964984416962,0.2442091107368469,0.003601184114813805,-0.2031922340393066,-0.304757833480835,-0.2790612578392029,-0.3061617016792297,-0.3943601846694946,-0.4776757061481476,-0.5580614805221558,-0.6024963855743408,-0.6805016994476318,-0.5432294607162476,-0.4119998812675476,-0.4718161523342133,-0.5295571684837341,-0.4676046073436737,-0.4218878746032715,-0.5352946519851685,-0.3766594529151917,-0.1812799423933029,-0.286812961101532,-0.2755210995674133,-0.189092680811882,-0.2396923750638962,-0.2554399371147156,-0.2155217081308365,-0.2117984592914581,-0.2251045256853104,-0.2260811179876328,-0.1981872022151947,-0.2656941413879395,-0.400158703327179,-0.3741569221019745,-0.3330790102481842,-0.4174321591854095,-0.5258339047431946,-0.6038392186164856,-0.4618060886859894,-0.1809137314558029,-0.1142002642154694,-0.1826227605342865,-0.1147495955228806,-6.103701889514923e-05,-0.04907376319169998,-0.1523483991622925,-0.1536301821470261,-0.112125001847744,-0.0079348124563694,0.01440473645925522,-0.09894100576639175,-0.1198767051100731,-0.1698660254478455,-0.2436597794294357,-0.2232123762369156,-0.188787505030632,-0.04974517226219177,0.1998351961374283,0.3506576716899872,0.5401166081428528,0.7328104376792908,0.7397686839103699,0.7555772662162781,0.7633289694786072,0.7793816924095154,0.7838373780250549,0.8062379956245422,0.7766960859298706,0.5799737572669983,0.5108188390731812,0.395641952753067,0.1636402457952499,0.0195928830653429,-0.0870998278260231,-0.1304971426725388,-0.08648945391178131,-0.02514725178480148,0.02014221623539925,-0.02032532729208469,-0.1997131258249283,-0.3565172255039215,-0.4370861053466797,-0.3103732466697693,-0.04113895073533058,-0.01580858789384365,-0.2434156388044357,-0.4034546911716461,-0.4036988317966461,-0.3791619539260864,-0.4320810437202454,-0.5167394280433655,-0.4696188271045685,-0.4204230010509491,-0.4148075878620148,-0.4646137952804565,-0.5233314037322998,-0.5524460673332214,-0.6151921153068542,-0.5236976146697998,-0.4745628237724304,-0.4289681613445282,-0.2921231687068939,-0.2113711982965469,-0.07873775810003281,0.01330607011914253,0.004455702379345894,-0.1356852948665619,-0.2865687906742096,-0.3499252200126648,-0.4416028261184692,-0.3325907289981842,-0.1724295765161514,-0.2740562260150909,-0.4685811996459961,-0.6598101854324341,-0.7594226002693176,-0.8326669931411743,-0.8578752875328064,-0.8202154636383057,-0.843653678894043,-0.809533953666687,-0.713278591632843,-0.6366161108016968,-0.4776146709918976,-0.4519791305065155,-0.4658955633640289,-0.3285622596740723,-0.3239845037460327,-0.1931821703910828,-0.00238044373691082,0.01287881098687649,0.1006500422954559,0.2336497157812119,0.3568834364414215,0.4066896438598633,0.425489068031311,0.5261390805244446,0.4647969007492065,0.4745628237724304,0.5919370055198669,0.5821710824966431,0.6070742011070251,0.6129337549209595,0.6284981966018677,0.6411328315734863,0.6504104733467102,0.670369565486908,0.6292306184768677,0.6090273857116699,0.5807061791419983,0.6396068930625916,0.7334208488464355,0.730246901512146,0.7496566772460938,0.7603991627693176,0.7702871561050415,0.790368378162384,0.7605822682380676,0.6437574625015259,0.5586107969284058,0.6134220361709595,0.6194036602973938,0.5724051594734192,0.5324259400367737,0.5298013091087341,0.5103304982185364,0.4108401834964752,0.4082766175270081,0.4273201823234558,0.4244514405727386,0.4181646108627319,0.2978606522083282,0.08673360198736191,0.02063051238656044,0.1464888453483582,0.2797326445579529,0.2489089667797089,-0.01806695759296417,-0.08386486768722534,0.079226054251194,0.1815851330757141,0.3158665597438812,0.3588976860046387,0.2468337118625641,-0.04516739398241043,-0.3419293761253357,-0.3307596147060394,-0.1903134286403656,-0.3281350135803223,-0.5489669442176819,-0.5752128958702087,-0.5246132016181946,-0.3330790102481842,-0.2323068976402283,-0.3147068619728088,-0.317453533411026,-0.3081148862838745,-0.3504745662212372,-0.3408917486667633,-0.4009521901607513,-0.4495376348495483,-0.4286629855632782,-0.4553361535072327,-0.491103857755661,-0.5030671358108521,-0.5277870893478394,-0.6205023527145386,-0.6271553635597229,-0.6487624645233154,-0.6656087040901184,-0.5841242671012878,-0.6247749328613281,-0.7165746092796326,-0.6775719523429871,-0.6358836889266968,-0.7492904663085938,-0.7845698595046997,-0.6308786273002625,-0.5033112764358521,-0.3817865550518036,-0.3424176871776581,-0.395275741815567,-0.3874630033969879,-0.425366997718811,-0.4239020943641663,-0.3283791542053223,-0.2509842216968536,-0.2667928040027618,-0.2647175490856171,-0.1213415935635567,-0.0479140616953373,-0.05383465066552162,-0.02111880853772163,-0.0874050110578537,-0.2015442401170731,-0.1387981772422791,-0.006103701889514923,0.1016876772046089,0.1380047053098679,0.2232734113931656,0.3676259517669678,0.3612781167030334,0.3467513024806976,0.2389599233865738,0.1442915201187134,0.1329386234283447,-0.02325510419905186,-0.1156041175127029,-0.1732230633497238,-0.2123477905988693,-0.1333048492670059,-0.1189001128077507,-0.08960234373807907,0.04132206365466118,0.1717581748962402,0.1732230633497238,0.1663258820772171,0.2501296997070312,0.219183936715126,0.09222693741321564,0.007812738418579102,-0.01470992155373096,-0.01525925472378731,-0.004516739398241043,-0.0039674062281847,0.05908383429050446,0.0398571752011776,-0.1040070801973343,-0.1422162503004074,-0.09125034511089325,0.03839228674769402,0.1980651319026947,0.2150334119796753,0.1854304671287537,0.2014221698045731,0.1730399429798126,0.1855525374412537,0.1594287008047104,0.09576708078384399,0.0875270888209343,0.1302530020475388,0.191167950630188,0.161076694726944,0.1305581778287888,0.1984923928976059,0.2169255614280701,0.1345255970954895,0.05255287513136864,-0.1710257232189178,-0.2990203499794006,-0.1682180315256119,-0.1861629039049149,-0.2864467203617096,-0.2832117676734924,-0.2799768149852753,-0.2905362248420715,-0.2813196182250977,-0.3789788484573364,-0.4510025382041931,-0.2905362248420715,-0.1152378916740417,0.1069368571043015,0.2269966751337051,0.09674367308616638,-0.0117801446467638,-0.1394695937633514,-0.1066316738724709,0.05450605973601341,0.1499069184064865,0.2909634709358215,0.3549302518367767,0.3600573837757111,0.236762598156929,0.05633717030286789,0.123538926243782,0.2234565317630768,0.2288277894258499,0.2854701280593872,0.4558244645595551,0.4931791126728058,0.3496810793876648,0.2793053984642029,0.07525864243507385,0.02868739888072014,0.09039582312107086,-0.06921598315238953,-0.1696829199790955,-0.1975768357515335,-0.1220740377902985,-0.07251197844743729,-0.1595507711172104,-0.2105166763067245,-0.09881893545389175,-0.005005035549402237,-0.005676442757248878,0.143742173910141,0.1493575870990753,-0.05914487317204475,-0.1103549301624298,0.0200811792165041,0.2227851152420044,0.2811365127563477,0.3399761915206909,0.3530381321907043,0.2124698609113693,0.2497634887695312,0.34791100025177,0.3214819729328156,0.2600176930427551,0.3012176752090454,0.3379619717597961,0.3129367828369141,0.2937711775302887,0.208746612071991,0.1286660432815552,-0.0079348124563694,-0.1892758011817932,-0.2226630449295044,-0.1510055810213089,0.02288888208568096,0.2073427587747574,0.09704886376857758,-0.1154210045933723,-0.2324900031089783,-0.329905092716217,-0.2934049367904663,-0.2223578542470932,-0.236945703625679,-0.2122257202863693,-0.2346873432397842,-0.3934446275234222,-0.4121219515800476,-0.3703726232051849,-0.4489883184432983,-0.4401989877223969,-0.3034150302410126,-0.1978820115327835,-0.2744224369525909,-0.2877895534038544,-0.06946013122797012,0.1218909248709679,0.08282723277807236,0.006042664870619774,0.1022980436682701,0.1662037968635559,0.2459791898727417,0.2714926600456238,0.1371501833200455,0.01440473645925522,-0.01715140230953693,0.02105777151882648,0.0158696249127388,-0.04272591322660446,-0.1956846863031387,-0.2724692523479462,-0.1835383176803589,-0.08795434236526489,-0.06927701830863953,-0.143620103597641,-0.1401409953832626,-0.1398358047008514,-0.2954802215099335,-0.1848201006650925,0.1776787638664246,0.2175969779491425,0.02642902918159962,0.02587969601154327,0.1080355271697044,-0.01727347634732723,0.01019318215548992,0.1320841163396835,0.07776116579771042,0.1333048492670059,0.1265297383069992,-0.0277718435972929,-0.06176946312189102,-0.1019928604364395,-0.1779839545488358,-0.08191168308258057,-0.08838160336017609,-0.2011780142784119,-0.1768852770328522,-0.1321451514959335,-0.01788384653627872,-0.08648945391178131,-0.2971282005310059,-0.4705343842506409,-0.599627673625946,-0.4027222394943237,-0.2594073414802551,-0.2406689673662186,-0.2045350521802902,-0.269295334815979,-0.2402417063713074,0.006164738908410072,0.1591845452785492,-0.01495406962931156,-0.04437391459941864,0.04571672901511192,0.1068147867918015,0.2002014219760895,0.1097445636987686,-0.004028443247079849,-0.09155552834272385,-0.0795922726392746,0.02960295416414738,0.1079744845628738,0.1445966958999634,0.08014160394668579,0.06213568523526192,0.09698782116174698,0.126102477312088,0.1102328598499298,-0.01196325570344925,-0.1652272045612335,-0.1804864704608917,-0.110904261469841,-0.07422101497650146,0.031434066593647,0.08819849044084549,0.1021759733557701,0.1175573021173477,-0.146183654665947,-0.3039033114910126,-0.1728568375110626,-0.06286813318729401,0.1289101839065552,0.189031645655632,0.2471388876438141,0.3667714595794678,0.299447625875473,0.2616046667098999,0.2816858291625977,0.2185125350952148,0.2132023125886917,0.2327951937913895,0.2092349082231522,0.3259376883506775,0.4047975242137909,0.2786950170993805,0.05413983762264252,0.05334635451436043,0.1278115212917328,0.1721854358911514,0.3797113001346588,0.352122575044632,0.1101718172430992,-0.02575762197375298,-0.0637836828827858,0.04474013671278954,0.2102115005254745,0.140995517373085,-0.1160924136638641,-0.239020973443985,-0.1652882546186447,-0.1766411364078522,-0.1991637945175171,-0.1850032061338425,-0.2843104302883148,-0.1364787817001343,-0.01147495955228806,-0.1221350729465485,-0.1592455804347992,-0.2609942853450775,-0.2373729646205902,-0.1418500393629074,-0.1281166970729828,0.01379436627030373,0.1094393730163574,0.08172857016324997,0.2073427587747574,0.3372295200824738,0.2939542829990387,0.2019715011119843,0.208990752696991,0.1597338765859604,-0.02899258397519588,0.02191228978335857,-0.02069154940545559,-0.1110873743891716,-0.01074251532554626,0.02722251042723656,0.003784295171499252,0.06939908862113953,0.1397137343883514,0.06530961394309998,0.02649006620049477,-0.07312235236167908,0.01287881098687649,0.1779229044914246,0.07690664380788803,-0.0717184990644455,-0.1267738938331604,-0.01818903163075447,0.007080294191837311,-0.01458784751594067,-0.004028443247079849,0.0791039764881134,0.1590624749660492,-0.03723258152604103,-0.0162358470261097,0.08258308470249176,-0.02514725178480148,-0.09625537693500519,-0.1618701815605164,-0.027405621483922,0.06579791009426117,0.03076265752315521,0.04699850454926491,0.1868343204259872,0.3924680352210999,0.4955595433712006,0.5075228214263916,0.2510452568531036,0.1308633685112,0.305063009262085,0.3179418444633484,0.1854304671287537,0.01269569993019104,-0.05249183624982834,-0.04522843286395073,0.007751701399683952,-0.003662221133708954,-0.2222357839345932,-0.1781060248613358,0.158513143658638,0.3006683588027954,0.1392254382371902,0.031434066593647,0.04553361609578133,-0.01532029174268246,0.1465498805046082,0.4034546911716461,0.3845332264900208,0.2759483754634857,0.0552385039627552,-0.173894464969635,-0.1978209763765335,-0.05218665301799774,0.06067079678177834,0.00555436871945858,-0.0240485854446888,-0.05145420879125595,-0.1082186326384544,-0.125797301530838,-0.09906308352947235,-0.128421887755394,-0.09802545607089996,0.08838160336017609,0.05102694779634476,0,0.1073641180992126,0.05743583664298058,-0.1189611479640007,-0.3596301078796387,-0.4071779549121857,-0.4672994315624237,-0.6126285791397095,-0.5764335989952087,-0.6491897106170654,-0.652180552482605,-0.5705130100250244,-0.7099826335906982,-0.7865230441093445,-0.4821924567222595,-0.2581255435943604,-0.3502914607524872,-0.2548905909061432,-0.1488692909479141,-0.1984313428401947,-0.1028473749756813,-0.1690115034580231,-0.3195287883281708,-0.3317972421646118,-0.4746238589286804,-0.5402386784553528,-0.448683112859726,-0.3394268751144409,-0.3236182630062103,-0.3707998991012573,-0.3541978299617767,-0.1862239390611649,0.1037018969655037,0.2172917872667313,0.1381267756223679,-0.002136295661330223,-0.0553605780005455,-0.0313730277121067,-0.06964323669672012,0.01867732778191566,0.1829279512166977,0.1893978714942932,0.1903744637966156,0.191167950630188,0.1982482373714447,0.1616870611906052,-0.05359050258994102,-0.1995300203561783,-0.07397686690092087,0.03772087767720222,-0.03094576857984066,-0.05175939202308655,-0.1983092725276947,-0.334604948759079,-0.1210974454879761,0.1384319663047791,0.1254310756921768,-0.2096011191606522,-0.2440260052680969,-0.03473006561398506,-0.0318002887070179,-0.1449018865823746,-0.34791100025177,-0.1989196389913559,0.007446516305208206,-0.1027253046631813,-0.1893368363380432,-0.1272621899843216,-0.09088411927223206,0.006103701889514923,0.1382488459348679,0.111941896378994,0.05328531935811043,-0.06909390538930893,-0.1839655786752701,-0.2355418503284454,-0.1814020276069641,-0.1519821733236313,-0.1624805480241776,-0.1150547787547112,-0.2376781553030014,-0.5186926126480103,-0.539384126663208,-0.3846552968025208,-0.3567613661289215,-0.2921842038631439,-0.174016535282135,-0.01654103212058544,-0.1380047053098679,-0.5276039838790894,-0.4779198467731476,-0.107058934867382,-0.06744590401649475,-0.08404797315597534,0.007263405248522758,-0.05078279972076416,0.003662221133708954,0.04016235843300819,-0.03375347331166267,0.02386547438800335,0.04309213533997536,-0.01904354989528656,-0.1754814237356186,-0.2095400840044022,0.008545182645320892,-0.02386547438800335,-0.1828669160604477,-0.1226844117045403,0.0158696249127388,0.03314310312271118,-0.01086458936333656,0.03430280461907387,0.04290902614593506,0.04022339731454849,0.0476088747382164,-0.004882961511611938,-0.07696767896413803,-0.05700857564806938,0.03918576613068581,0.05236976221203804,0.04541154205799103,0.05627613142132759,0.04815820977091789,0.06115909293293953,-0.01825006864964962,-0.1052278205752373,0.0008545182645320892,0.06842249631881714,0.05462813377380371,0.06567583233118057,0.06207465007901192,0.06732383370399475,0.06781212985515594,0.07031464576721191,0.07263405621051788,0.07391583174467087,0.07708975672721863,0.07818841934204102,0.08130130916833878,0.08239997923374176,0.08539079129695892,0.0869777500629425,0.08929716050624847,0.09241005033254623,0.09216590225696564,0.09906308352947235,0.09308145195245743,0.109683521091938,0.04907376319169998,-0.04571672901511192,0.008606219664216042,0.1027863398194313,0.1043122634291649,0.01568651385605335,0.0631733164191246,0.1225623339414597,0.1054719686508179,0.1237830743193626,0.06793420016765594,0.08789330720901489,0.1300698816776276,0.1181676685810089,0.128543958067894,0.125919371843338,0.1304971426725388,0.1319620311260223,0.1338541805744171,0.1367839574813843,0.1378215849399567,0.140995517373085,0.1423993706703186,0.1449018865823746,0.1467940360307693,0.1488082557916641,0.1509445458650589,0.1527146250009537,0.1550340354442596,0.1566209942102432,0.1591235101222992,0.1604052931070328,0.1627246886491776,0.1644947677850723,0.1660817265510559,0.1688283979892731,0.1679738759994507,0.1751762479543686,0.1674855798482895,0.1849421709775925,0.1522873640060425,0.02893154695630074,-0.08777123689651489,-0.03906369209289551,0.04675435647368431,0.04126102477312088,-0.07849361002445221,-0.1497848480939865,0.09448530524969101,-0.03680532425642014,-0.3116550147533417,-0.2539750337600708,-0.2168034911155701,-0.2009338736534119,-0.2094180136919022,-0.1640675067901611,-0.1558275073766708,-0.2481765151023865,-0.0872829407453537,0.09161656349897385,-0.01025421917438507,-0.0954618975520134,-0.04303110018372536,0.009826960042119026,-0.1685842424631119,-0.2879726588726044,-0.2014221698045731,-0.1817682385444641,-0.1110873743891716,0.05890072509646416,0.1010162681341171,0.09955137968063354,0.005493331700563431,-0.2182683795690536,-0.257271021604538,-0.2426221519708633,-0.2880336940288544,-0.1319009959697723,0.0795312374830246,-0.04309213533997536,-0.1068758219480515,0.09234900772571564,-0.04614398628473282,-0.2076479345560074,-0.1210364103317261,-0.1540574431419373,-0.07318338751792908,-0.04522843286395073,-0.193792536854744,-0.1447187662124634,-0.06646931171417236,-0.02301095612347126,0.00952177494764328,-0.06274605542421341,-0.02978606522083282,0.04852443188428879,0.04693746939301491,0.05023346841335297,0.04870754107832909,0.04956205934286118,0.05194250494241714,0.02496414072811604,-0.00158696249127388,0.05395672470331192,0.04248176515102386,-0.03747672960162163,0.03283791616559029,0.04998932033777237,0.02276680804789066,0.03601184114813805,0.0399182103574276,0.05493331700563431,0.04596087709069252,0.04803613573312759,-0.1452681124210358,-0.3197118937969208,-0.2407910376787186,-0.3145847916603088,-0.3839228451251984,-0.1356242597103119,0.02893154695630074,0.02270577102899551,0.01831110566854477,0.03015228733420372,0.008301034569740295,-0.03057954646646976,0.0158696249127388,0.02691732533276081,0.01879940181970596,0.02227851189672947,0.02526932582259178,-0.08014160394668579,-0.1025421917438507,0.02093569748103619,-0.008423108607530594,-0.1276284009218216,-0.1175573021173477,-0.01745658740401268,0.02893154695630074,-0.0240485854446888,-0.2575151920318604,-0.2501296997070312,-0.04437391459941864,-0.0005493331700563431,0.006775109097361565,0.0007324442267417908,0.005676442757248878,-0.002441480755805969,-0.01031525619328022,0.009155552834272385,-0.002929776906967163,0.009582811966538429,-0.007751701399683952,-0.03454695269465446,-0.001709036529064178,0.004882961511611938,0.0005493331700563431,-0.03473006561398506,-0.01861629076302052,0.008667256683111191,-0.003540147095918655,0.003845332190394402,-0.0006103701889514923,0.001647999510169029,0.00079348124563694,0.0006103701889514923,0.001220740377902985,0.0004272591322660446,0.001037629321217537,0.0004882961511611938,0.00079348124563694,0.0006103701889514923,0.0004882961511611938,0.00079348124563694,0.0001831110566854477,0.0009155552834272385,-6.103701889514923e-05,0.0008545182645320892,6.103701889514923e-05,0.0001831110566854477,0.001159703359007835,-0.001953184604644775,0.004943998530507088,-0.01672414317727089,-0.01538132876157761,0.004211554303765297,-0.002807702869176865,0.001403851434588432,-0.002319406718015671,0.002075258642435074,-0.004211554303765297,0.005615405738353729,-0.01483199559152126,-0.03833124786615372,0.0001831110566854477,-0.0007324442267417908,-0.002685628831386566,0.0002441480755805969,-0.002929776906967163,0,-0.002319406718015671,-0.0006714072078466415,-0.001647999510169029,-0.001098666340112686,-0.001342814415693283,-0.001281777396798134,-0.001159703359007835,-0.001220740377902985,-0.001159703359007835,-0.001159703359007835,-0.001098666340112686,-0.001098666340112686,-0.001037629321217537,-0.0009765923023223877,-0.0009765923023223877,-0.0008545182645320892,-0.0008545182645320892,-0.00079348124563694,-0.0007324442267417908,-0.0006714072078466415,-0.0005493331700563431,-0.0004882961511611938,-0.0004272591322660446,-0.0003662221133708954,-0.0002441480755805969,-0.0001831110566854477,-0.0001220740377902985,0,6.103701889514923e-05,0.0001831110566854477,0.0002441480755805969,0.0003662221133708954,0.0004882961511611938,0.0005493331700563431,0.0006714072078466415,0.00079348124563694,0.0009155552834272385,0.001037629321217537,0.001159703359007835,0.001220740377902985,0.001281777396798134,0.001525925472378731,0.001525925472378731,0.001831110566854477,0.001770073547959328,0.002075258642435074,0.002014221623539925,0.002197332680225372,0.002502517774701118,0.002014221623539925,0.003723258152604103,-0.001403851434588432,-0.0008545182645320892,0.004028443247079849,0.002502517774701118,0.003418073058128357,0.00317392498254776,0.003418073058128357,0.003418073058128357,0.003784295171499252,0.003418073058128357,0.004272591322660446,0.003357036039233208,0.00476088747382164,0.003540147095918655,0.004638813436031342,0.004882961511611938,-0.01013214513659477,-0.001098666340112686,0.006836146116256714,0.002929776906967163,0.005615405738353729,0.0039674062281847,0.005127109587192535,0.004638813436031342,0.004882961511611938,0.005005035549402237,0.004943998530507088,0.005188146606087685,0.005066072568297386,0.005249183624982834,0.005188146606087685,0.005310220643877983,0.005310220643877983,0.005371257662773132,0.005371257662773132,0.005432294681668282,0.005432294681668282,0.005432294681668282,0.005432294681668282,0.005432294681668282,0.005432294681668282,0.005432294681668282,0.005432294681668282,0.005371257662773132,0.005371257662773132,0.005310220643877983,0.005310220643877983,0.005249183624982834,0.005249183624982834,0.005188146606087685,0.005066072568297386,0.005005035549402237,0.005005035549402237,0.004882961511611938,0.004699850454926491,0.004943998530507088,0.004455702379345894,0.004638813436031342,0.004699850454926491,0.003540147095918655,0.005737479776144028,0.001953184604644775,0.007019257172942162,0.0006714072078466415,0.00714133121073246,0.001037629321217537,0.004943998530507088,0.002136295661330223,-0.09344767779111862,-0.0200811792165041,0.007202368229627609,-0.001770073547959328,-0.0004272591322660446,-0.1640064716339111,-0.06604205816984177,0.01916562393307686,-0.01696829125285149,0.006164738908410072,-0.009277626872062683,0,-0.004882961511611938,-0.003479110077023506,-0.002990813925862312,-0.004821924492716789,-0.002807702869176865,-0.004638813436031342,-0.003479110077023506,-0.004211554303765297,-0.004028443247079849,-0.004089480265974998,-0.004089480265974998,-0.004150517284870148,-0.004150517284870148,-0.004150517284870148,-0.004150517284870148,-0.004089480265974998,-0.004089480265974998,-0.004028443247079849,-0.0039674062281847,-0.003906369209289551,-0.003784295171499252,-0.003723258152604103,-0.003601184114813805,-0.003479110077023506,-0.003295999020338058,-0.00317392498254776,-0.003051850944757462,-0.002563554793596268,-0.002929776906967163,-0.001831110566854477,-0.002624591812491417,-0.001281777396798134,-0.001770073547959328,-0.001403851434588432,0.0001220740377902985,-0.002624591812491417,0.003662221133708954,-0.005920590832829475,0.01116977445781231,-0.03411969542503357,-0.0714743509888649,-0.001159703359007835,0.002502517774701118,-0.0009155552834272385,0.004455702379345894,0.0001831110566854477,0.005127109587192535,0.002319406718015671,0.005432294681668282,0.004516739398241043,0.006103701889514923,0.006530961021780968,0.007263405248522758,0.008239997550845146,0.008789330720901489,0.009765923023223877,0.01062044128775597,0.01147495955228806,0.01245155185461044,0.01336710713803768,0.01434369944036007,0.01532029174268246,0.01635792106389999,0.01739555038511753,0.01849421672523022,0.0195928830653429,0.02069154940545559,0.02191228978335857,0.02301095612347126,0.02429273352026939,0.02551347389817238,0.02679525129497051,0.02807702869176865,0.02929776906967163,0.03064058348536491,0.0320444367825985,0.033448]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>generic_gunshot</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[0.1502731442451477,0.1527451425790787,0.1672414392232895,0.2074037939310074,0.2337717860937119,0.2662740051746368,0.3369548618793488,0.4237495064735413,0.4812463819980621,0.4760887622833252,0.4048890769481659,0.299844354391098,0.1904049813747406,0.1055940464138985,0.09344767779111862,0.0796838253736496,0.003753776662051678,-0.0632648691534996,-0.079256571829319,-0.03424176946282387,0.01638844050467014,0.01889095827937126,0.0157170332968235,0.05267494916915894,0.1028778925538063,0.09851375222206116,0.06292916834354401,0.05600146576762199,0.07425153255462646,0.1097445636987686,0.1446272134780884,0.1836909055709839,0.2402111887931824,0.2773216962814331,0.2910550236701965,0.2762840688228607,0.2236091196537018,0.1720938682556152,0.1485335826873779,0.158452108502388,0.2029175758361816,0.2667012512683868,0.2846461236476898,0.2386852651834488,0.1614734381437302,0.07498397678136826,-0.04852443188428879,-0.2268746048212051,-0.3471480309963226,-0.3628345727920532,-0.3433942794799805,-0.3411969244480133,-0.330027163028717,-0.2927335500717163,-0.256965845823288,-0.2222357839345932,-0.2014526873826981,-0.1992858648300171,-0.2229682356119156,-0.2787865698337555,-0.3484908640384674,-0.3875850737094879,-0.3633228540420532,-0.2761009633541107,-0.1489303261041641,-0.0196844395250082,0.1049836724996567,0.1794488430023193,0.1633961051702499,0.113254189491272,0.09204382449388504,0.08297982811927795,0.04403821006417274,0.01373332925140858,0.03009125031530857,0.0870693102478981,0.191595196723938,0.2786339819431305,0.2910855412483215,0.2752159237861633,0.2606585919857025,0.2210150510072708,0.1522568464279175,0.09433270990848541,0.05413983762264252,0.04531998559832573,0.07415997982025146,0.1022370085120201,0.1015350818634033,0.0950346365571022,0.123569443821907,0.1907101720571518,0.2665486633777618,0.2759483754634857,0.2163457125425339,0.1559800952672958,0.1287575960159302,0.1375774443149567,0.1728568375110626,0.2199163734912872,0.2610858380794525,0.2924588620662689,0.3121738433837891,0.3315531015396118,0.3423261344432831,0.3277993202209473,0.2989898324012756,0.2606891095638275,0.2292855679988861,0.2205877900123596,0.2130497097969055,0.1953489780426025,0.156102180480957,0.09302041679620743,0.04544205963611603,0.0200811792165041,-0.01519821770489216,-0.09399700909852982,-0.1951048374176025,-0.2411572635173798,-0.2279427498579025,-0.2139652669429779,-0.2012085318565369,-0.1916867643594742,-0.23929563164711,-0.3493453860282898,-0.4424878656864166,-0.4592730402946472,-0.4168523252010345,-0.3764763474464417,-0.3946043252944946,-0.4566484689712524,-0.4900967478752136,-0.4334543943405151,-0.3243507146835327,-0.2198858559131622,-0.1185338944196701,-0.01455732900649309,0.08178960531949997,0.1251258850097656,0.08352915942668915,0.002136295661330223,-0.03357036039233208,-0.03912473097443581,-0.05981627851724625,-0.1089815944433212,-0.176335945725441,-0.1929685324430466,-0.1368755102157593,-0.06454664468765259,-0.02346873469650745,0.031525619328022,0.1196020394563675,0.1633045375347137,0.1088900417089462,0.07528916001319885,0.1231727078557014,0.1489303261041641,0.1698660254478455,0.1743217259645462,0.1920224577188492,0.2634357810020447,0.2831812500953674,0.2558061480522156,0.2298348993062973,0.2306283712387085,0.2131412774324417,0.1402325481176376,0.09414960443973541,0.08062990009784698,0.07577745616436005,0.1010162681341171,0.1288796663284302,0.09671315550804138,0.04870754107832909,0.0477309487760067,0.05227820575237274,0.02298043854534626,-0.02111880853772163,-0.004333628341555595,0.05777153745293617,0.1093783378601074,0.1429487019777298,0.1290627717971802,0.09060945361852646,0.05945005640387535,0.04116946831345558,0.02273629046976566,-0.03360087797045708,-0.08465834707021713,-0.09241005033254623,-0.0473342090845108,0.03653065487742424,0.06802576035261154,0.04562517255544662,0.02609332650899887,0.009887997061014175,-0.05017242953181267,-0.1130100414156914,-0.1027558222413063,-0.02722251042723656,0.0716574639081955,0.1112399697303772,0.09582812339067459,0.06219672411680222,0.03595080599188805,0.02505569718778133,0.01745658740401268,-0.00436414685100317,-0.05026398599147797,-0.05398724228143692,-0.01760918088257313,-0.008270516060292721,-0.04315317422151566,-0.08325449377298355,-0.0868556797504425,-0.05731376260519028,-0.02322458662092686,0.01940977200865746,0.05423139035701752,0.03366191685199738,-0.012268440797925,-0.02337717823684216,0.02975554764270782,0.1070284098386765,0.1535996645689011,0.1489303261041641,0.08819849044084549,0.01223792228847742,-0.0397351011633873,-0.0711691677570343,-0.08130130916833878,-0.07760857045650482,-0.06042664870619774,-0.01712088473141193,0.04034547135233879,0.07974486798048019,0.07885982841253281,0.07312235236167908,0.09323404729366302,0.1342814415693283,0.1600695848464966,0.146092101931572,0.1126438155770302,0.09350871294736862,0.09262367337942123,0.09671315550804138,0.128208264708519,0.1592150628566742,0.1599169969558716,0.1477706283330917,0.1442915201187134,0.1680654287338257,0.2081972658634186,0.2478103041648865,0.2743003666400909,0.2738120555877686,0.2454908937215805,0.2150334119796753,0.1989196389913559,0.1876583099365234,0.171300396323204,0.1532639563083649,0.1373027712106705,0.1220740377902985,0.1063570082187653,0.08377330750226974,0.05627613142132759,0.03012176975607872,0.0004272591322660446,-0.005493331700563431,0.0397961363196373,0.1007110849022865,0.1399578899145126,0.1568040996789932,0.1648609936237335,0.1795709133148193,0.1959898620843887,0.1680349111557007,0.08615375310182571,0.02023377269506454,-0.01120029296725988,-0.04657124727964401,-0.09811700880527496,-0.1549729853868484,-0.1524704694747925,-0.06137272343039513,0.04446546733379364,0.08038575202226639,0.05502487346529961,0.05905331671237946,0.1051057502627373,0.1205175966024399,0.08484145998954773,0.0557573176920414,0.05890072509646416,0.06390576064586639,0.05838190764188766,0.06393627822399139,0.08493301272392273,0.1029999703168869,0.09891048818826675,0.06616412848234177,0.06466872245073318,0.1217383369803429,0.1908627599477768,0.2056947499513626,0.1373638063669205,0.05920590832829475,0.05307168886065483,0.1230506300926208,0.1934568285942078,0.1812799423933029,0.0949736014008522,0.001647999510169029,-0.03115939907729626,-0.0121463667601347,-0.008392590098083019,-0.002136295661330223,0.0394909530878067,0.08148442208766937,0.07815790176391602,0.04943998530507088,0.04184087738394737,0.05011139437556267,0.06442457437515259,0.08618427067995071,0.09720145165920258,0.07681509107351303,0.05981627851724625,0.06863612681627274,0.07861568033695221,0.06469924002885818,0.02926725149154663,0.01065095979720354,0.02059999480843544,0.03530991449952126,0.0079348124563694,-0.05499435588717461,-0.09161656349897385,-0.09463790059089661,-0.1004364117980003,-0.1244239658117294,-0.1454512178897858,-0.1395001113414764,-0.1085238233208656,-0.07559435069561005,-0.04181035980582237,-0.004181035794317722,-0.003936887718737125,-0.03897213563323021,-0.05493331700563431,-0.01864681020379066,0.0277413260191679,0.01846369914710522,-0.03707998991012573,-0.08426160365343094,-0.06418042629957199,-0.01205481123179197,0.009216589853167534,-0.01062044128775597,-0.04831080138683319,-0.04113895073533058,-0.01748710684478283,-0.01507614366710186,-0.02240058593451977,-0.06927701830863953,-0.1421246975660324,-0.1834772825241089,-0.2092654258012772,-0.2779320776462555,-0.3535874485969543,-0.3793145418167114,-0.3372905552387238,-0.2262642234563828,-0.1193578913807869,-0.06778161227703094,-0.08145390450954437,-0.1510055810213089,-0.206549271941185,-0.2184209674596786,-0.2107913494110107,-0.2139957845211029,-0.23917356133461,-0.2717062830924988,-0.3097628653049469,-0.3411358892917633,-0.3271279036998749,-0.2774437665939331,-0.2212591916322708,-0.171483501791954,-0.1553086936473846,-0.1809442490339279,-0.2167424559593201,-0.2033448219299316,-0.17398601770401,-0.1779229044914246,-0.1655323952436447,-0.1175573021173477,-0.06125064939260483,-0.01846369914710522,0.01052888575941324,0.04492324590682983,0.07461775839328766,0.06399731338024139,0.02002014219760895,-0.04266487807035446,-0.1341288536787033,-0.2143925279378891,-0.2209540158510208,-0.1538438051939011,-0.0717795342206955,-0.03439436107873917,-0.06643879413604736,-0.1343729943037033,-0.1953794956207275,-0.2502822875976562,-0.287087619304657,-0.2751548886299133,-0.2224189043045044,-0.1520432084798813,-0.09237952530384064,-0.0794702023267746,-0.1198767051100731,-0.191351056098938,-0.257118433713913,-0.2847377061843872,-0.2688985764980316,-0.2493057101964951,-0.2742393314838409,-0.3057954609394073,-0.2979827225208282,-0.2761619985103607,-0.256416529417038,-0.2117679417133331,-0.1237220391631126,-0.03866695240139961,-0.002349925227463245,-0.003845332190394402,-0.01486251410096884,-0.03244117647409439,-0.07544175535440445,-0.1371196657419205,-0.1957762390375137,-0.2298348993062973,-0.234138011932373,-0.2281563729047775,-0.2112491279840469,-0.1845759451389313,-0.1861629039049149,-0.2132328301668167,-0.2381054162979126,-0.2662434875965118,-0.2923062741756439,-0.2980437576770782,-0.2714011073112488,-0.2057252675294876,-0.1329996585845947,-0.09015167504549026,-0.07449568063020706,-0.07998901605606079,-0.07394634932279587,-0.05063020810484886,-0.02316354960203171,-0.004303109832108021,0.002105777151882648,-0.00634784996509552,-0.04971465095877647,-0.1015045642852783,-0.1665700227022171,-0.1926328390836716,-0.146092101931572,-0.05230872705578804,0.05261391028761864,0.1005584895610809,0.1037934496998787,0.05127109587192535,-0.01733451336622238,-0.06140324100852013,-0.08047731220722198,-0.03723258152604103,0.04406872764229774,0.09698782116174698,0.06976531445980072,-0.004547257907688618,-0.06472975760698318,-0.0715048685669899,-0.03079317696392536,0.005066072568297386,0.0158696249127388,0.006958220154047012,-0.01483199559152126,-0.01919614337384701,0.03103732503950596,0.1088900417089462,0.173955500125885,0.191228985786438,0.1638538837432861,0.1505172848701477,0.1367534399032593,0.1293374449014664,0.1141392290592194,0.031525619328022,-0.04055909812450409,-0.07049775868654251,-0.0950346365571022,-0.1077913790941238,-0.09826960414648056,-0.06265450268983841,-0.01834162510931492,0.0194708090275526,0.05377361550927162,0.08297982811927795,0.08301034569740295,0.07217627763748169,0.06781212985515594,0.04239020869135857,0.013702810741961,0.005890072323381901,-6.103701889514923e-05,0.007751701399683952,0.01785332895815372,0.02285836450755596,0.04251228272914886,0.05139316990971565,0.05230872705578804,0.05767998471856117,0.09363079071044922,0.1347392201423645,0.1245765537023544,0.07770012319087982,0.006958220154047012,-0.06152531504631042,-0.09170812368392944,-0.1138340383768082,-0.1684926897287369,-0.2138737142086029,-0.2155217081308365,-0.1684621721506119,-0.1070284098386765,-0.06808679550886154,-0.06259346008300781,-0.1059297472238541,-0.1368755102157593,-0.1207007020711899,-0.06424146145582199,-0.007568590342998505,0.02188177220523357,0.0479140616953373,0.03118991665542126,-0.01019318215548992,-0.01300088502466679,0.01089510787278414,0.03900265693664551,0.05279702320694923,0.05322428047657013,0.05627613142132759,0.05343791097402573,0.01443525496870279,-0.04242072999477386,-0.02880947291851044,0.05862605571746826,0.145786926150322,0.1689199507236481,0.112063966691494,0.0005493331700563431,-0.128299817442894,-0.161137729883194,-0.06027405709028244,0.09057893604040146,0.1847590506076813,0.1594592183828354,0.06918545812368393,0.01074251532554626,-0.002441480755805969,-0.0195928830653429,-0.0200506616383791,-0.01141392253339291,-0.0313119925558567,-0.02990813925862312,0.008514664135873318,0.03854487836360931,0.05215613171458244,0.09643848985433578,0.1692556589841843,0.2000793516635895,0.1475264728069305,0.05249183624982834,-0.002807702869176865,-0.01208532974123955,-0.02462843805551529,-0.0318002887070179,-0.0158391073346138,-0.01733451336622238,-0.06826990842819214,-0.1147495955228806,-0.1223181858658791,-0.1294595152139664,-0.109530933201313,-0.05298013240098953,-0.02172917872667313,-0.01416058838367462,0.009277626872062683,0.05951109528541565,0.1050752252340317,0.09152501076459885,0.02938932552933693,-0.0240485854446888,-0.04501480236649513,-0.03680532425642014,-0.01373332925140858,-0.004852443002164364,-0.04168828576803207,-0.1052583381533623,-0.1468245536088943,-0.1470076590776443,-0.1101718172430992,-0.06787316501140594,-0.04620502516627312,-0.02285836450755596,0.0002441480755805969,-0.02252265997231007,-0.07339701801538467,-0.1042512282729149,-0.1253700405359268,-0.1332743316888809,-0.1171910762786865,-0.09350871294736862,-0.07568590342998505,-0.0553605780005455,-0.04931791126728058,-0.08386486768722534,-0.08908353000879288,-0.03122043609619141,0.07763908803462982,0.2146977186203003,0.3147068619728088,0.3491927981376648,0.3226721882820129,0.2524796426296234,0.1621143221855164,0.1060518175363541,0.09665212035179138,0.1136204078793526,0.1180455982685089,0.05093539133667946,-0.0240485854446888,-0.03500473126769066,-0.007629627361893654,0.04934842884540558,0.1210974454879761,0.143742173910141,0.1074556708335876,0.05740531533956528,0.0319833979010582,0.0475173182785511,0.05841242894530296,0.02578814141452312,0.03802606463432312,0.1368144750595093,0.2330088168382645,0.2457960695028305,0.1932737231254578,0.1785943210124969,0.2161626070737839,0.2961210906505585,0.4026306867599487,0.4667500853538513,0.4868617951869965,0.4776757061481476,0.3909115791320801,0.251899778842926,0.1684011369943619,0.1484115123748779,0.131076991558075,0.09729301184415817,0.06698812544345856,0.06665242463350296,0.1155735924839973,0.1541489958763123,0.1776177287101746,0.1852473467588425,0.1603747606277466,0.1625721007585526,0.1464888453483582,0.1407513618469238,0.171239361166954,0.1676686853170395,0.1311380416154861,0.07412946224212646,-0.00317392498254776,-0.0553300566971302,-0.06076235324144363,-0.05725272372364998,-0.06759849935770035,-0.08224738389253616,-0.03915524855256081,0.04156621173024178,0.1113315224647522,0.1544541716575623,0.1318094432353973,0.07834101468324661,0.04998932033777237,0.03552354499697685,0.05426191166043282,0.1498153656721115,0.2578508853912354,0.2917264401912689,0.2450636327266693,0.1804559528827667,0.1123691499233246,0.04583880305290222,0.02450636401772499,0.03707998991012573,0.06247138977050781,0.08011108636856079,0.05124057829380035,-0.01702932827174664,-0.04965361580252647,-0.02630695514380932,0.005859553813934326,0.02511673420667648,0.02182073518633842,-0.02481154911220074,-0.08575700968503952,-0.113284707069397,-0.1198461875319481,-0.1331522613763809,-0.1399884074926376,-0.1078829318284988,-0.05108798667788506,0.02172917872667313,0.0867946445941925,0.1032441183924675,0.09219641983509064,0.07745597511529922,0.07019257545471191,0.07882931083440781,0.1025116741657257,0.1479232162237167,0.1931821703910828,0.2172002345323563,0.2167119383811951,0.1644337326288223,0.09161656349897385,0.02847377024590969,-0.0321054719388485,-0.0791344940662384,-0.09302041679620743,-0.04974517226219177,0.0201727356761694,0.06427197903394699,0.06628620624542236,0.05001983791589737,0.01449629198759794,-0.02310251258313656,-0.01483199559152126,0.01657155156135559,0.04022339731454849,0.02175969816744328,-0.02832117676734924,-0.05114902183413506,-0.06421094387769699,-0.1077303364872932,-0.1621753573417664,-0.1856746077537537,-0.1803033500909805,-0.1474959552288055,-0.1223487034440041,-0.1632740199565887,-0.2420423030853271,-0.3052156269550323,-0.3254798948764801,-0.3099459707736969,-0.2642292678356171,-0.1987975686788559,-0.1380657404661179,-0.08200323581695557,-0.02990813925862312,0.01934873498976231,0.0316171757876873,0.0162358470261097,0.01705984771251678,0.00753807183355093,-0.04068117216229439,-0.06732383370399475,-0.003051850944757462,0.07525864243507385,0.0875576063990593,0.06097598373889923,0.01763969846069813,-0.02755821496248245,-0.05212561413645744,-0.04190191254019737,-0.008514664135873318,0.006836146116256714,0.005249183624982834,0.01013214513659477,0.008087405003607273,0.01663258858025074,0.08166753500699997,0.1995605379343033,0.3108310103416443,0.3341776728630066,0.2850733995437622,0.2293771207332611,0.1316873729228973,-0.01110873743891716,-0.09451582282781601,-0.06085390970110893,0.01315347757190466,0.04135258123278618,0.06793420016765594,0.1177709251642227,0.1174657419323921,0.05395672470331192,-0.0239265114068985,-0.07214576005935669,-0.09900204837322235,-0.1446272134780884,-0.2020935714244843,-0.2284920811653137,-0.1902523934841156,-0.1417584717273712,-0.1175267770886421,-0.09753715991973877,-0.09179967641830444,-0.09826960414648056,-0.1289712190628052,-0.1523178815841675,-0.1440473645925522,-0.1597949117422104,-0.2022156417369843,-0.219428077340126,-0.219306007027626,-0.2254097163677216,-0.2526932656764984,-0.2920621335506439,-0.2733542919158936,-0.2202825993299484,-0.1882381737232208,-0.1626331359148026,-0.1199072226881981,-0.07300027459859848,-0.02948088012635708,0.02551347389817238,0.05316324532032013,0.07589953392744064,0.1030610054731369,0.08789330720901489,0.05017242953181267,0.04971465095877647,0.05194250494241714,-0.02682577073574066,-0.1138645559549332,-0.1322061866521835,-0.125858336687088,-0.1474349200725555,-0.176152840256691,-0.1789300143718719,-0.1452070623636246,-0.113223671913147,-0.09674367308616638,-0.002655110321938992,0.1466414332389832,0.2688070237636566,0.317728191614151,0.2647785842418671,0.1406292915344238,0.02172917872667313,-0.02029480971395969,-0.01651051454246044,-0.04019287601113319,-0.1492660343647003,-0.2534257173538208,-0.1848201006650925,-0.02972502820193768,0.027375103905797,-0.06540116667747498,-0.2407605201005936,-0.3573412299156189,-0.3635364770889282,-0.3071382939815521,-0.2659993171691895,-0.2346568256616592,-0.1853083968162537,-0.143467515707016,-0.09360026568174362,-0.07348857074975967,-0.09393597394227982,-0.1251258850097656,-0.1101107820868492,-0.06808679550886154,-0.05005035549402237,-0.02142399363219738,-0.01907406933605671,-0.04153569042682648,-0.04266487807035446,-0.03332621231675148,-0.08005005121231079,-0.1389507800340652,-0.1140781864523888,-0.02999969571828842,0.0633869469165802,0.1200598180294037,0.08270516246557236,-0.04013184085488319,-0.1566209942102432,-0.2055421620607376,-0.1505783200263977,-0.02276680804789066,0.1341288536787033,0.2527237832546234,0.287575900554657,0.2558671832084656,0.1554612815380096,0.01931821741163731,-0.1061433777213097,-0.1745963990688324,-0.2226325273513794,-0.234229564666748,-0.1899777203798294,-0.1521042585372925,-0.1067537441849709,-0.03842280432581902,0.006714072078466415,0.004882961511611938,-0.01089510787278414,-0.02111880853772163,-0.01049836724996567,0.02877895534038544,0.05728324130177498,0.01062044128775597,-0.0400708019733429,-0.03469954431056976,-0.0394604317843914,-0.04147465527057648,-6.103701889514923e-05,0.05801568552851677,0.1014130041003227,0.1413617432117462,0.1707510650157928,0.2081972658634186,0.2584002315998077,0.2926114797592163,0.3224585652351379,0.3422650694847107,0.2938627302646637,0.1751762479543686,0.09186071157455444,0.08819849044084549,0.1104464828968048,0.1094088554382324,0.09320352971553802,0.1148411482572556,0.1834772825241089,0.2136295735836029,0.2005066126585007,0.1823480874300003,0.1203344836831093,0.02050843834877014,-0.06213568523526192,-0.09698782116174698,-0.1255226284265518,-0.1584215760231018,-0.1297341883182526,-0.03115939907729626,0.0392773225903511,0.003326517529785633,-0.108462780714035,-0.1854304671287537,-0.1944639384746552,-0.1676992028951645,-0.09228797256946564,-0.01675466261804104,0.03347880393266678,0.05954161286354065,0.008453627116978168,-0.1212195232510567,-0.208746612071991,-0.1598864644765854,-0.04147465527057648,0.04297006130218506,0.0637836828827858,0.02880947291851044,-0.0393383577466011,-0.08893093466758728,-0.1343424767255783,-0.1694387644529343,-0.1675466150045395,-0.1778923869132996,-0.186681717634201,-0.1679433584213257,-0.1443220376968384,-0.08505508303642273,0.03241065889596939,0.1393780261278152,0.1818903237581253,0.1628772914409637,0.1212195232510567,0.09643848985433578,0.0791039764881134,0.06073183566331863,0.03674428537487984,-0.006195257417857647,-0.02133243903517723,0.02407910488545895,0.04644917324185371,0.02728354744613171,0.01287881098687649,-0.03118991665542126,-0.1220740377902985,-0.1853083968162537,-0.1676686853170395,-0.1036713793873787,-0.02246162295341492,0.05716116726398468,0.1328165531158447,0.194036677479744,0.2201605290174484,0.2413708865642548,0.257148951292038,0.2354197800159454,0.1822870522737503,0.1157567054033279,0.03302102908492088,-0.0277718435972929,-0.02398754842579365,0.03061006590723991,0.08505508303642273,0.113193154335022,0.1101412996649742,0.04846339300274849,0.01104770042002201,0.03659169375896454,0.01861629076302052,-0.05923642590641975,-0.1371501833200455,-0.1593371331691742,-0.1371807008981705,-0.1445966958999634,-0.1638538837432861,-0.125827819108963,-0.06427197903394699,-0.05743583664298058,-0.07770012319087982,-0.06845301389694214,-0.06207465007901192,-0.08020264655351639,-0.1348002552986145,-0.2414319217205048,-0.365520179271698,-0.4623248875141144,-0.5259864926338196,-0.5632190704345703,-0.5015411972999573,-0.3311868607997894,-0.1659291386604309,-0.06384472548961639,-0.0237739197909832,-0.01257362589240074,-0.02816858515143394,-0.08529923111200333,-0.1204870790243149,-0.1201208531856537,-0.1358378827571869,-0.1507004052400589,-0.1111789271235466,-0.01470992155373096,0.05313272401690483,0.04391613602638245,0.02523880824446678,0.01232947781682014,-0.006225775927305222,-0.01800592057406902,-0.04956205934286118,-0.1101107820868492,-0.1689504683017731,-0.2003234922885895,-0.2195196449756622,-0.2204351872205734,-0.2074648290872574,-0.2026429027318954,-0.1633350700139999,-0.08349864184856415,-0.02200384624302387,-0.01278725545853376,-0.02508621476590633,0.01593066193163395,0.08343760669231415,0.1068758219480515,0.1185338944196701,0.1201818883419037,0.107272557914257,0.09991759806871414,0.08877834677696228,0.07593005150556564,0.1025421917438507,0.219275489449501,0.3569750189781189,0.4168523252010345,0.3918881714344025,0.352580338716507,0.3498641848564148,0.3580126464366913,0.3668935298919678,0.3501083552837372,0.3224280476570129,0.3678701221942902,0.4662007391452789,0.5180211663246155,0.4763634204864502,0.4124881625175476,0.3847773671150208,0.365215003490448,0.3392132222652435,0.3116550147533417,0.2506485283374786,0.1776787638664246,0.1976989060640335,0.23947873711586,0.2359080761671066,0.2019715011119843,0.171361431479454,0.2105166763067245,0.2469557821750641,0.2457960695028305,0.2331919372081757,0.1754203885793686,0.08777123689651489,0.05352946743369102,-0.002716147340834141,-0.09421063959598541,-0.1325724124908447,-0.1481978893280029,-0.1530808508396149,-0.1824701726436615,-0.204290896654129,-0.1640064716339111,-0.07565538585186005,-0.01385540328919888,-0.02478102967143059,-0.0712607204914093,-0.09012115746736526,-0.07617419958114624,-0.1210669279098511,-0.2046266049146652,-0.2865687906742096,-0.3632007837295532,-0.426221489906311,-0.4726401567459106,-0.4476454854011536,-0.3924070000648499,-0.3712576627731323,-0.34778892993927,-0.3247474730014801,-0.3030793070793152,-0.2637714743614197,-0.1776177287101746,-0.05322428047657013,0.02716147340834141,0.08349864184856415,0.1441389173269272,0.1766411364078522,0.1651051342487335,0.1272927075624466,0.06805627793073654,-0.02746665850281715,-0.1124301925301552,-0.112033449113369,-0.05923642590641975,-0.05667287111282349,-0.08322397619485855,-0.09436323493719101,-0.09692678600549698,-0.09042634069919586,-0.07193212956190109,-0.03518784046173096,0.03039643540978432,0.09634693711996078,0.1092257425189018,0.06122013181447983,-0.01916562393307686,-0.0870082676410675,-0.1087374463677406,-0.0712607204914093,-0.02508621476590633,-0.03372295200824738,-0.1069063395261765,-0.2055116444826126,-0.2668843567371368,-0.2605365216732025,-0.2114322334527969,-0.17380291223526,-0.1791131347417831,-0.1872615814208984,-0.1662343144416809,-0.1592455804347992,-0.1326639652252197,-0.1032441183924675,-0.1509140282869339,-0.241828665137291,-0.335337370634079,-0.3903622627258301,-0.3769646286964417,-0.3387249410152435,-0.3074739873409271,-0.2627338469028473,-0.2200079411268234,-0.2263557910919189,-0.2919400632381439,-0.3571581244468689,-0.3728141188621521,-0.3440046310424805,-0.2905056774616241,-0.2623676359653473,-0.2395092695951462,-0.1985839456319809,-0.160954624414444,-0.09143345803022385,0.007354960776865482,0.06561479717493057,0.04971465095877647,-0.0001525925472378731,-0.01525925472378731,0.05151524394750595,0.1608325392007828,0.2244026064872742,0.2273323833942413,0.1788689792156219,0.08026368170976639,-0.03839228674769402,-0.1680959463119507,-0.2849818468093872,-0.2307199388742447,-0.04632709920406342,0.02569658495485783,-0.003387554548680782,-0.1112399697303772,-0.2805261313915253,-0.4050721824169159,-0.4523148238658905,-0.4320505261421204,-0.4185003340244293,-0.3725089132785797,-0.223883792757988,-0.05435346439480782,0.01901303231716156,-0.0316476933658123,-0.113376259803772,-0.1601306200027466,-0.2148503065109253,-0.3366802036762238,-0.4584795534610748,-0.4663533568382263,-0.3314004838466644,-0.1508529931306839,-0.02172917872667313,0.07455671578645706,0.1145054474473,0.04809717088937759,-0.09979552775621414,-0.2142094224691391,-0.237037256360054,-0.2155217081308365,-0.2173223048448563,-0.2550736963748932,-0.2512283623218536,-0.2186040878295898,-0.1319620311260223,-0.01376384776085615,-0.009460737928748131,-0.09253212064504623,-0.1355021893978119,-0.07757805287837982,-0.00833155307918787,0.0004882961511611938,-0.004669331945478916,-0.01760918088257313,-0.02114932797849178,0.04336680099368095,0.08185064047574997,-0.00753807183355093,-0.1208532974123955,-0.13104647397995,-0.0556962788105011,0.003692739643156528,0.003875850699841976,-0.04840235784649849,-0.10843226313591,-0.1121860444545746,-0.01681569963693619,0.1164891496300697,0.176274910569191,0.1477401107549667,0.1244850009679794,0.1699880957603455,0.2146061658859253,0.2199774235486984,0.2398754805326462,0.2777489423751831,0.2595599293708801,0.2050843834877014,0.1007416024804115,-0.02273629046976566,-0.09115878492593765,-0.1505478024482727,-0.1503036618232727,-0.08200323581695557,-0.02468947507441044,0.0200811792165041,0.1504257321357727,0.3697927892208099,0.5155186653137207,0.4447767436504364,0.2599871754646301,0.1624805480241776,0.1652272045612335,0.2123172730207443,0.2304147481918335,0.1853389143943787,0.07684560865163803,-0.02496414072811604,-0.03527939692139626,0.01483199559152126,0.04022339731454849,0.07550279051065445,0.160954624414444,0.221716970205307,0.2724387347698212,0.2853785753250122,0.1944334208965302,0.02642902918159962,-0.1065401136875153,-0.1686452776193619,-0.156071662902832,-0.05157628282904625,0.08371227234601974,0.1749931275844574,0.1582689881324768,0.0711996853351593,-0.01239051483571529,-0.0197149571031332,-0.004699850454926491,-0.0313119925558567,-0.02475051209330559,-0.01684621721506119,-0.09741508215665817,-0.1805169880390167,-0.1445966958999634,0.006225775927305222,0.2025208324193954,0.317117840051651,0.3539231419563293,0.3589587211608887,0.2760704457759857,0.1530198007822037,0.1076387837529182,0.09915463626384735,0.05029450356960297,-0.04031495004892349,-0.1503341794013977,-0.2124698609113693,-0.2229072004556656,-0.2357554882764816,-0.224280521273613,-0.1534775793552399,-0.110751673579216,-0.08368175476789474,-0.09814752638339996,-0.1808831989765167,-0.1943418681621552,-0.1986754983663559,-0.2504959404468536,-0.2456129640340805,-0.188787505030632,-0.1503646969795227,-0.1543321013450623,-0.2004150450229645,-0.2137516438961029,-0.2015747576951981,-0.1843318045139313,-0.1760002374649048,-0.1878719478845596,-0.1457258760929108,-0.08175908774137497,-0.04269539564847946,-0.06851405650377274,-0.06909390538930893,-0.02362132631242275,-0.009430219419300556,-0.01266518142074347,0.01519821770489216,0.09155552834272385,0.1113010048866272,0.06393627822399139,-0.005493331700563431,-0.05392620712518692,-0.1453291475772858,-0.2649311721324921,-0.3533738255500793,-0.425977349281311,-0.4575945436954498,-0.3978087604045868,-0.23947873711586,-0.1573839485645294,-0.05780205875635147,0.01376384776085615,-0.04104739427566528,-0.06167790666222572,-0.09634693711996078,-0.1256446987390518,-0.1420941799879074,-0.1564989238977432,-0.1010162681341171,0.05325479805469513,0.2206183075904846,0.2903836071491241,0.1723990589380264,-0.07370220124721527,-0.188818022608757,-0.143711656332016,-0.0552385039627552,0.02050843834877014,0.1785943210124969,0.3848689198493958,0.4701681435108185,0.4097720384597778,0.2162236422300339,0.06704916805028915,0.1056245639920235,0.251655638217926,0.3121738433837891,0.252082884311676,0.2071901559829712,0.1709952056407928,0.1536912173032761,0.2182683795690536,0.2853785753250122,0.2553178369998932,0.1705069094896317,0.08279671519994736,0.03375347331166267,0.07892086356878281,0.1204565539956093,0.1112704873085022,0.1641895771026611,0.2102725356817245,0.1079744845628738,-0.01779229193925858,-0.06088442727923393,-0.01251258887350559,0.1067232266068459,0.2075563818216324,0.2529374063014984,0.1526841074228287,-0.0320444367825985,-0.1369975954294205,-0.1101718172430992,0.002471999265253544,0.05493331700563431,0.01867732778191566,-0.006530961021780968,0.02172917872667313,-0.01776177249848843,-0.1462752223014832,-0.2598956227302551,-0.2610553205013275,-0.1696523874998093,-0.1081881150603294,-0.02969451062381268,0.03512680530548096,-0.01208532974123955,-0.1517380326986313,-0.3159276247024536,-0.3801995813846588,-0.2807092368602753,-0.1928159445524216,-0.2298959344625473,-0.2754600644111633,-0.3063142895698547,-0.3234656751155853,-0.3388470113277435,-0.3447676002979279,-0.2723471820354462,-0.1847895681858063,-0.1520432084798813,-0.1368144750595093,-0.1031525656580925,-0.06015198305249214,-0.03225806355476379,-0.06424146145582199,-0.1442609876394272,-0.2121341526508331,-0.2295907437801361,-0.1487167030572891,0.002258369699120522,0.128513440489769,0.1604968458414078,0.1166417449712753,0.0950346365571022,0.09930723160505295,0.05786309391260147,-0.01901303231716156,-0.04284798726439476,-0.04467909783124924,-0.1204260364174843,-0.2094790488481522,-0.2157048285007477,-0.1446882486343384,-0.07013153284788132,-0.02862636186182499,0.001678518019616604,0.00753807183355093,-0.1005584895610809,-0.2944425940513611,-0.3941160440444946,-0.3399761915206909,-0.2486342936754227,-0.239326149225235,-0.2745445072650909,-0.2755516171455383,-0.2655415534973145,-0.2917874753475189,-0.3120517730712891,-0.2947782874107361,-0.3183385729789734,-0.4049195945262909,-0.4328745305538177,-0.3383281826972961,-0.2429578602313995,-0.206427201628685,-0.1978820115327835,-0.2152775675058365,-0.2423169612884521,-0.2385326772928238,-0.1535080969333649,-0.06601153314113617,-0.08841212093830109,-0.1929074972867966,-0.2480849623680115,-0.1222571507096291,0.08905301243066788,0.1683401018381119,0.1242408528923988,0.1086764112114906,0.1727958023548126,0.2509231865406036,0.2452162206172943,0.1572313606739044,0.06256294250488281,0.008453627116978168,0.06097598373889923,0.1667226105928421,0.208960235118866,0.1995910555124283,0.1851863116025925,0.2433240711688995,0.377819150686264,0.4512466788291931,0.3887142539024353,0.2883693873882294,0.2790612578392029,0.3268837630748749,0.2939542829990387,0.1469161063432693,-0.01440473645925522,-0.07287820428609848,0.003204443491995335,0.09564501047134399,0.1067232266068459,0.079317606985569,0.05798516795039177,0.01675466261804104,-0.0234076976776123,-0.03396710008382797,-0.07382427155971527,-0.1154820397496223,-0.1265907734632492,-0.1277504861354828,-0.1443220376968384,-0.1767937242984772,-0.1856135725975037,-0.2119205296039581,-0.251625120639801,-0.2945036292076111,-0.3402203321456909,-0.3281044960021973,-0.234290599822998,-0.07074190676212311,0.1268959641456604,0.2927030324935913,0.3032624423503876,0.1804559528827667,0.1026642695069313,0.1264076679944992,0.2008117884397507,0.2967925071716309,0.3604846298694611,0.3130588829517365,0.2118289768695831,0.1650746166706085,0.1568040996789932,0.1809137314558029,0.2461317777633667,0.3108920454978943,0.3530991673469543,0.335184782743454,0.3068330883979797,0.2643513381481171,0.1034272313117981,-0.06503494083881378,-0.08594012260437012,0.008880886249244213,0.128543958067894,0.1836909055709839,0.1104770079255104,0.0313119925558567,0.0199285876005888,-0.02383495680987835,-0.06213568523526192,-0.04223761707544327,0.01452681049704552,0.1212805584073067,0.257148951292038,0.4226813614368439,0.5942564010620117,0.7152012586593628,0.747672975063324,0.6610614061355591,0.4959563016891479,0.3390301167964935,0.3020721971988678,0.3708304166793823,0.4863734841346741,0.5380107760429382,0.4100466966629028,0.2883999049663544,0.3122043609619141,0.3939329087734222,0.4045838713645935,0.3093051016330719,0.1727958023548126,0.08490249514579773,0.1113315224647522,0.1921140104532242,0.2682271897792816,0.3309427201747894,0.3705862462520599,0.4054689109325409,0.3809320330619812,0.2669148743152618,0.1926328390836716,0.219367042183876,0.2942899763584137,0.3333231508731842,0.2758262753486633,0.1583910584449768,0.08658101409673691,0.01055940426886082,-0.1376384794712067,-0.2228766679763794,-0.2283394932746887,-0.2092959433794022,-0.2057863026857376,-0.208746612071991,-0.2174748927354813,-0.2187261581420898,-0.1870479434728622,-0.1883297264575958,-0.2202520817518234,-0.352092057466507,-0.4493850469589233,-0.3798333704471588,-0.2803735435009003,-0.2271492630243301,-0.2182378619909286,-0.1858272105455399,-0.1787469089031219,-0.269112229347229,-0.3807794451713562,-0.3928952813148499,-0.3366802036762238,-0.2494277805089951,-0.160954624414444,-0.1059907823801041,-0.04666280001401901,-0.09445478767156601,-0.2053590565919876,-0.2559587359428406,-0.2473220080137253,-0.1989501565694809,-0.1389812976121902,-0.0395825058221817,0.06729331612586975,0.1190527081489563,0.08572649210691452,0.03762932121753693,0.08908353000879288,0.1808526813983917,0.2444532662630081,0.3666188418865204,0.52220219373703,0.635670006275177,0.6781212687492371,0.6016113758087158,0.4843897819519043,0.377697080373764,0.2610248029232025,0.1347087025642395,0.05221717059612274,0.01986755058169365,-0.07290872186422348,-0.1945860236883163,-0.2294991910457611,-0.140873447060585,-0.02072206884622574,-0.03616443276405334,-0.1722769886255264,-0.317026287317276,-0.4073915779590607,-0.3979003131389618,-0.3309427201747894,-0.2729575634002686,-0.252204954624176,-0.3252357542514801,-0.4497512876987457,-0.4930570423603058,-0.5418255925178528,-0.6688131093978882,-0.7630543112754822,-0.730338454246521,-0.5306253433227539,-0.2641376852989197,0.03061006590723991,0.2426221519708633,0.2573931217193604,0.223944827914238,0.1900387555360794,0.1872005313634872,0.236701563000679,0.2574236392974854,0.2884609401226044,0.3719595968723297,0.4346446096897125,0.4321115612983704,0.4495071172714233,0.5144504904747009,0.5856196880340576,0.6368297338485718,0.5445722937583923,0.352244645357132,0.282082587480545,0.3920407593250275,0.4978789687156677,0.3839533627033234,0.1861323863267899,0.05407879874110222,0.01892147585749626,0.193853572010994,0.4641560018062592,0.6247749328613281,0.5698721408843994,0.4032105505466461,0.2629779875278473,0.1364787817001343,0.1204565539956093,0.1524399518966675,0.1080355271697044,0.08325449377298355,0.193823054432869,0.3577074408531189,0.400677502155304,0.3934446275234222,0.4246040284633636,0.4578081667423248,0.4123355746269226,0.2553178369998932,0.1279335916042328,0.09106723219156265,0.02215643785893917,-0.02316354960203171,0.001678518019616604,-0.1068758219480515,-0.2535172700881958,-0.1634571403264999,0.03109836205840111,0.06015198305249214,-0.009796441532671452,-0.05987731739878654,-0.1255226284265518,-0.2379528135061264,-0.3268227279186249,-0.3604541122913361,-0.4175847768783569,-0.4591814875602722,-0.4626300930976868,-0.4270454943180084,-0.3744926154613495,-0.304635763168335,-0.189123198390007,-0.03772087767720222,0.1854915022850037,0.3537095189094543,0.2716757655143738,-0.01773125492036343,-0.2885830402374268,-0.4621417820453644,-0.5330668091773987,-0.4512771964073181,-0.3190099895000458,-0.2985320687294006,-0.3505661189556122,-0.4125797152519226,-0.4716635644435883,-0.4630268216133118,-0.3898434340953827,-0.3034455478191376,-0.352244645357132,-0.5271462202072144,-0.6128422021865845,-0.5028839707374573,-0.3623157441616058,-0.3393047749996185,-0.3071077466011047,-0.1903744637966156,-0.06002990901470184,0.02105777151882648,0.0711996853351593,0.06985686719417572,0.07229834794998169,0.09097567945718765,0.01910458691418171,-0.06845301389694214,-0.04135258123278618,0.06952116638422012,0.1342204064130783,0.110812708735466,0.05435346439480782,0.007751701399683952,-0.02383495680987835,-0.005188146606087685,0.01092562638223171,0.0201727356761694,0.08151493966579437,0.1742912083864212,0.2459181547164917,0.1843318045139313,0.04171880334615707,-0.03564561903476715,-0.03778191655874252,-0.01449629198759794,0.04110843315720558,0.001281777396798134,-0.1920834928750992,-0.3273110091686249,-0.3005462884902954,-0.1339457333087921,0.05160680040717125,0.176305428147316,0.234290599822998,0.2046571224927902,0.1706595122814178,0.1709646880626678,0.1169774457812309,-0.06283760815858841,-0.3118686378002167,-0.4335154294967651,-0.3918881714344025,-0.3264259696006775,-0.1897335797548294,0.03701895102858543,0.2251655608415604,0.3715933859348297,0.5109714269638062,0.5579394102096558,0.5036469697952271,0.3623767793178558,0.08133182674646378,-0.1582689881324768,-0.1685842424631119,-0.01553392130881548,0.0952787846326828,0.02636799216270447,-0.07486190646886826,-0.1381267756223679,-0.2007507532835007,-0.1966002434492111,-0.143467515707016,-0.0715048685669899,-0.002655110321938992,0.04248176515102386,0.05719168856739998,0.01397747732698917,-0.02612384408712387,0.01733451336622238,0.03247169405221939,-0.08105716109275818,-0.1896114945411682,-0.2029786109924316,-0.1169469282031059,0.05331583693623543,0.2056031972169876,0.2645344436168671,0.2720420062541962,0.2385937124490738,0.1900387555360794,0.1832026094198227,0.2338938564062119,0.3398236036300659,0.3611865639686584,0.300027459859848,0.3072298467159271,0.4062929153442383,0.5050813555717468,0.4746238589286804,0.3271584212779999,0.2059999406337738,0.1186864823102951,0.03369243443012238,0.07434309273958206,0.1692556589841843,0.1663258820772171,0.08569597452878952,0.00833155307918787,-0.02606280706822872,-0.03036591783165932,-0.03894161805510521,-0.08108767867088318,-0.1635181754827499,-0.3059480488300323,-0.4020813703536987,-0.3912167847156525,-0.3509933650493622,-0.4049195945262909,-0.5493331551551819,-0.6335337162017822,-0.6184881329536438,-0.5248268246650696,-0.4333933591842651,-0.4467604458332062,-0.5271157026290894,-0.4941557049751282,-0.3556016683578491,-0.2051454186439514,-0.00634784996509552,0.1496627777814865,0.1832941621541977,0.1040070801973343,-0.05331583693623543,-0.1089205592870712,-0.02557451091706753,0.004394665360450745,-0.008575701154768467,0.03665272891521454,0.1438337415456772,0.2112796455621719,0.1644337326288223,0.1137119680643082,0.1178624853491783,0.1661427617073059,0.2442396283149719,0.2970976829528809,0.2388683706521988,0.1018707826733589,-0.01718192175030708,-0.06695760786533356,0.006225775927305222,0.06952116638422012,0.004058961756527424,-0.07000946253538132,-0.06451612710952759,-0.0791344940662384,-0.1511581838130951,-0.1151768565177917,0.02514725178480148,0.1478011459112167,0.2432935535907745,0.2620013952255249,0.2030396461486816,0.1693777292966843,0.2206793427467346,0.3499862551689148,0.5041352510452271,0.5702078342437744,0.5060579180717468,0.3805353045463562,0.3315531015396118,0.3965269923210144,0.4146549999713898,0.3157139718532562,0.1147801131010056,-0.0632953867316246,-0.04998932033777237,0.1008941903710365,0.2009643912315369,0.2142704576253891,0.2113406807184219,0.1468245536088943,0.04306161776185036,-0.05413983762264252,-0.156407356262207,-0.2528153359889984,-0.3036591708660126,-0.2530594766139984,-0.1450849920511246,-0.04809717088937759,0.06073183566331863,0.1841792017221451,0.2541886568069458,0.299752801656723,0.3020416796207428,0.1769463121891022,0.05667287111282349,0.06045716628432274,0.1480147689580917,0.2655415534973145,0.4084902405738831,0.4994964301586151,0.4030884802341461,0.2490005195140839,0.1379436701536179,0.03659169375896454,-0.01345866266638041,-0.04449598863720894,-0.04080324620008469,0.01501510664820671,0.08868678659200668,0.1495712101459503,0.1139866337180138,-0.05310220643877983,-0.1926633566617966,-0.1420636624097824,0.04956205934286118,0.2655110359191895,0.3817255198955536,0.3532822728157043,0.2271492630243301,0.1134067848324776,0.1543931365013123,0.2968840599060059,0.3223670125007629,0.1902218759059906,0.02850428782403469,-0.1188085600733757,-0.2321237772703171,-0.2585528194904327,-0.1633655875921249,-0.04028443247079849,-0.001129184849560261,0.03396710008382797,0.08249153196811676,0.07089449465274811,0.07336650043725967,0.09009063988924026,0.02398754842579365,-0.08853419870138168,-0.1663563996553421,-0.1996215730905533,-0.1815851330757141,-0.06839197874069214,0.09610278904438019,0.2094180136919022,0.2784813940525055,0.3277688026428223,0.2928251028060913,0.2383495569229126,0.1892147660255432,0.1025727093219757,0.03750724717974663,-0.04068117216229439,-0.1004669368267059,-0.09002960473299026,0.02130191959440708,0.1196020394563675,0.08447523415088654,0.1380657404661179,0.3386639058589935,0.5286416411399841,0.5554063320159912,0.4500259459018707,0.412884920835495,0.448225349187851,0.4808496236801147,0.4971770346164703,0.5330973267555237,0.5936460494995117,0.6013977527618408,0.5613879561424255,0.5598315596580505,0.5617542266845703,0.5063020586967468,0.4539933502674103,0.4529862403869629,0.3658559024333954,0.2173833400011063,0.2609027326107025,0.3793450593948364,0.3574327826499939,0.1998046785593033,-0.01953184604644775,-0.1422162503004074,-0.1271401047706604,-0.1603137254714966,-0.3036896884441376,-0.3875545561313629,-0.3611865639686584,-0.2810449600219727,-0.1792657226324081,-0.1264992207288742,-0.2157963812351227,-0.3574327826499939,-0.3909420967102051,-0.3531907200813293,-0.3409527838230133,-0.3795587122440338,-0.4394360184669495,-0.4054383933544159,-0.2075868993997574,0.04837183654308319,0.2441480755805969,0.3060396015644073,0.3058870136737823,0.3236182630062103,0.3904843330383301,0.4662312567234039,0.4824060797691345,0.4419995844364166,0.2894070148468018,0.2642292678356171,0.4470046162605286,0.5660268068313599,0.5181737542152405,0.4499038755893707,0.473311573266983,0.5873287320137024,0.7419049739837646,0.6772057414054871,0.3920407593250275,0.1091036722064018,0.04620502516627312,0.09860530495643616,0.1005279719829559,0.09140293300151825,-0.03823969140648842,-0.256355494260788,-0.4768517017364502,-0.4592120051383972,-0.2222663015127182,-0.02499466016888618,0.047853022813797,0.02526932582259178,0.05771050229668617,0.08575700968503952,0.07510605454444885,0.07309182733297348,0.1288796663284302,0.219275489449501,0.2792138457298279,0.3097323477268219,0.2423474788665771,0.05316324532032013,-0.1677907705307007,-0.3383587002754211,-0.3588976860046387,-0.2364268898963928,-0.1842402368783951,-0.2643818557262421,-0.4312570691108704,-0.5489364266395569,-0.6136051416397095,-0.6761375665664673,-0.5442060828208923,-0.2952055335044861,-0.1675771325826645,-0.1226233690977097,-0.08401745557785034,-0.0194708090275526,0.0950346365571022,0.1223181858658791,0.1051667854189873,0.05044709518551826,-0.0710470899939537,-0.1118808537721634,-0.1331827789545059,-0.2031311988830566,-0.1904965341091156,-0.0200811792165041,0.1080965623259544,0.1724906116724014,0.2507400810718536,0.3267311751842499,0.5014801621437073,0.6925565600395203,0.7017120718955994,0.5613269209861755,0.3335368037223816,0.1323282569646835,0.1344340294599533,0.1193273738026619,0.1074861884117126,0.2449415624141693,0.2592242062091827,0.1207312270998955,0.03280739858746529,0.08670308440923691,0.2443006634712219,0.3128757476806641,0.2162846773862839,0.09033478796482086,-0.003509628586471081,0.02096621692180634,0.01715140230953693,-0.1379741877317429,-0.3004852533340454,-0.2959379851818085,-0.1027863398194313,0.03756828606128693,0.1746879518032074,0.2689901292324066,0.28211310505867,0.1758476495742798,0.01705984771251678,0.1748405396938324,0.3017670214176178,0.2320932596921921,0.1675466150045395,0.07809686660766602,0.1342509239912033,0.3028351664543152,0.4334543943405151,0.5402691960334778,0.5406354069709778,0.3125095367431641,0.02581865899264812,-0.08365123718976974,-0.06924650073051453,-0.03033539839088917,-0.01730399578809738,-0.04129154235124588,-0.06759849935770035,-0.1019318252801895,-0.126041442155838,-0.07525864243507385,0.08917508274316788,0.2714621424674988,0.2048402428627014,-0.0397961363196373,-0.1652882546186447,-0.1379436701536179,-0.03521836176514626,-0.06534013152122498,-0.04574724659323692,0.08249153196811676,0.0321359895169735,0.004791405983269215,0.04879909753799438,0.1623889952898026,0.3056733906269073,0.2471388876438141,0.01321451459079981,-0.1651356518268585,-0.1634876579046249,-0.1647999584674835,-0.1322367042303085,0.02444532699882984,0.06411939114332199,-0.09720145165920258,-0.2025818675756454,-0.1152378916740417,0.06930753588676453,0.2284310460090637,0.3108310103416443,0.3744926154613495,0.3918271362781525,0.4053468406200409,0.4220099449157715,0.3891109824180603,0.4839320182800293,0.5899838209152222,0.5113376379013062,0.4635761678218842,0.4714194238185883,0.4895474016666412,0.5352946519851685,0.574938178062439,0.6240425109863281,0.6511428952217102,0.6492507457733154,0.5793939232826233,0.5040131807327271,0.2836084961891174,0.05505539104342461,0.1694997996091843,0.3387554585933685,0.4181035757064819,0.3421735167503357,0.1594592183828354,0.1199377402663231,0.1848201006650925,0.3017975389957428,0.3971373736858368,0.3644520342350006,0.2637409567832947,0.1655629128217697,0.1508529931306839,0.1698049902915955,-0.0636310949921608,-0.365245521068573,-0.4714804589748383,-0.3917355835437775,-0.1636097282171249,-0.09628589451313019,-0.3116550147533417,-0.4593951106071472,-0.3519394397735596,-0.1927549093961716,-0.0790124237537384,-0.06753746420145035,-0.1683401018381119,-0.3137607872486115,-0.4022339582443237,-0.399914562702179,-0.3820612132549286,-0.443800151348114,-0.6483962535858154,-0.7559434771537781,-0.713644802570343,-0.5341349244117737,-0.2159794867038727,-0.009765923023223877,0.008789330720901489,-0.03714102506637573,-0.03833124786615372,-0.03347880393266678,-0.234260082244873,-0.6158635020256042,-0.8304391503334045,-0.7149571180343628,-0.2493972629308701,0.2879116237163544,0.4194769263267517,0.1166417449712753,-0.08478041738271713,0.02566606737673283,0.1249122619628906,0.2425000816583633,0.4080324769020081,0.4221014976501465,0.2500076293945312,0.01269569993019104,-0.1178319677710533,0.05871761217713356,0.4247871339321136,0.6727194786071777,0.7575609683990479,0.7337870597839355,0.6278267502784729,0.4125797152519226,0.1513107717037201,0.08590960502624512,0.2102420181035995,0.34772789478302,0.5040436983108521,0.4756614863872528,0.3360393047332764,0.2670980095863342,0.2989898324012756,0.5115512609481812,0.6487929821014404,0.617297887802124,0.4384899437427521,0.2338328212499619,0.1478011459112167,0.1202734485268593,0.07840204983949661,0.1004974544048309,0.2352366745471954,0.377819150686264,0.474105030298233,0.4714804589748383,0.4506057798862457,0.4409619569778442,0.4456007480621338,0.4107181131839752,0.2529068887233734,0.01864681020379066,-0.1998351961374283,-0.2851344347000122,-0.1484115123748779,0.08035523444414139,0.08215583115816116,-0.1632435023784637,-0.4197821021080017,-0.4806360006332397,-0.2930692434310913,0.03405865654349327,0.2296212613582611,0.2718893885612488,0.2009033411741257,0.04431287571787834,-0.007080294191837311,-0.09079256653785706,-0.2263252735137939,-0.2618488073348999,-0.176030769944191,-0.06399731338024139,-0.06497390568256378,-0.1052888557314873,-0.04226813465356827,0.001342814415693283,-0.001647999510169029,0.09976501017808914,0.2740257084369659,0.4419385492801666,0.5287637114524841,0.4820093512535095,0.3207495212554932,0.2624286711215973,0.3497726321220398,0.4208197295665741,0.3717764914035797,0.2771996259689331,0.2789391875267029,0.3837092220783234,0.5016937851905823,0.4982451796531677,0.5093844532966614,0.4809411764144897,0.4153874218463898,0.4191717207431793,0.5012665390968323,0.7333902716636658,0.8752098083496094,0.748832643032074,0.3856929242610931,0.0556657612323761,-0.05795465037226677,-0.04266487807035446,0.0557573176920414,0.1048310771584511,0.1103549301624298,0.1671193540096283,0.1960509121417999,0.1885128319263458,0.1573534309864044,0.2462538480758667,0.4544816315174103,0.4116031229496002,0.1656544655561447,-0.04715109616518021,-0.1109958216547966,-0.04339732229709625,0.00634784996509552,0.1228980347514153,0.3404645025730133,0.4491103887557983,0.3395489454269409,0.1349528431892395,-0.1035187840461731,-0.4031495153903961,-0.5362407565116882,-0.3408612310886383,-0.07492294162511826,0.06625568121671677,0.05890072509646416,0.1065706387162209,0.2876369655132294,0.4465773403644562,0.5670949220657349,0.4615009129047394,0.1674245446920395,-0.05993835255503654,-0.1742912083864212,-0.282143622636795,-0.3614001870155334,-0.2578508853912354,-0.02011169865727425,0.1139561161398888,-0.1417584717273712,-0.5409405827522278,-0.6205633878707886,-0.430616170167923,-0.2084719389677048,-0.05035554245114326,0.0398571752011776,0.05496383458375931,-0.03399762138724327,-0.2187871932983398,-0.3383892476558685,-0.2459181547164917,-0.09439375251531601,-0.1695303171873093,-0.3337199091911316,-0.2838831841945648,-0.1056245639920235,0.04608295112848282,0.01083407085388899,-0.1232642605900764,-0.1821344643831253,-0.3085726499557495,-0.3853572309017181,-0.3607287704944611,-0.3375957608222961,-0.2538224458694458,-0.0716879814863205,0.1180761158466339,0.08529923111200333,-0.01825006864964962,0.04342783987522125,-0.002288888208568096,-0.2578203678131104,-0.3976561725139618,-0.3658864200115204,-0.3188574016094208,-0.3003937005996704,-0.3393963575363159,-0.4165776669979095,-0.4374217987060547,-0.4624469876289368,-0.5029755830764771,-0.4054383933544159,-0.3465987145900726,-0.3945738077163696,-0.4140446186065674,-0.478499710559845,-0.5887630581855774,-0.600482165813446,-0.5261390805244446,-0.574175238609314,-0.7865230441093445,-0.8891872763633728,-0.7414166927337646,-0.6255073547363281,-0.6756492853164673,-0.7586596012115479,-0.7375408411026001,-0.635120689868927,-0.5693838596343994,-0.5761589407920837,-0.6813257336616516,-0.6608783006668091,-0.3698538243770599,-0.1618701815605164,-0.1199072226881981,-0.0952482670545578,-0.143528550863266,-0.1018707826733589,0.01074251532554626,0.1118808537721634,0.221472829580307,0.3279824256896973,0.4688253402709961,0.4803308248519897,0.3181249499320984,0.05758842825889587,-0.1179540380835533,-0.05081331729888916,0.1327860355377197,0.1607409864664078,0.079317606985569,0.1157261878252029,0.1656239479780197,0.1528977304697037,0.1648609936237335,0.2447584420442581,0.2634662985801697,0.1619006991386414,0.05987731739878654,0.128391370177269,0.2771385908126831,0.3494979739189148,0.4116031229496002,0.3669850826263428,0.1604968458414078,-0.1070284098386765,-0.2545243799686432,-0.1550035029649734,0.1200598180294037,0.3493759036064148,0.3104342818260193,0.1295205503702164,0.03665272891521454,0.01654103212058544,0.0551469475030899,0.05047761648893356,-0.002960295416414738,0.09625537693500519,0.1772515028715134,0.07525864243507385,-0.1500289887189865,-0.3621326386928558,-0.4336680173873901,-0.3495590090751648,-0.05383465066552162,0.1770073622465134,0.07470931112766266,-0.1361735910177231,-0.2304757833480835,-0.1807916462421417,0.0160832554101944,0.2556230425834656,0.3069246411323547,0.2493057101964951,0.219367042183876,0.1624805480241776,0.1489608436822891,0.1621143221855164,0.09076204895973206,-0.02505569718778133,-0.05450605973601341,-0.09970396757125854,-0.2299569696187973,-0.2915738523006439,-0.28199103474617,-0.3258766531944275,-0.4716025292873383,-0.5266274213790894,-0.4597613513469696,-0.3597216606140137,-0.1966917961835861,-0.04333628341555595,0.0196844395250082,-0.01767021790146828,-0.124759666621685,-0.2477187365293503,-0.1757866144180298,0.07388531416654587,0.191442608833313,0.2205267548561096,0.3233436048030853,0.4335459470748901,0.4773705303668976,0.412640780210495,0.3181554675102234,0.269264817237854,0.171391949057579,-0.02795495465397835,-0.2114017158746719,-0.3195287883281708,-0.4575640261173248,-0.5588549375534058,-0.5089266896247864,-0.3111972510814667,-0.1040070801973343,-0.04864650592207909,-0.1049531549215317,-0.1896420121192932,-0.365062415599823,-0.6221198439598083,-0.6970122456550598,-0.6207159757614136,-0.6024963855743408,-0.5920895934104919,-0.4792626798152924,-0.2284005284309387,0.0235297717154026,0.1468550711870193,0.2543107271194458,0.287148654460907,0.130771815776825,0.02038636431097984,0.05462813377380371,0.09903256595134735,0.01635792106389999,-0.04257332161068916,0.07672353088855743,0.2203131169080734,0.2537614107131958,0.1427045464515686,-0.03265480697154999,-0.1146275252103806,0.123416855931282,0.5238807201385498,0.7416913509368896,0.7354045510292053,0.5843684077262878,0.4318979382514954,0.3851740956306458,0.4704123139381409,0.6836146116256714,0.8375499844551086,0.7930845022201538,0.7501449584960938,0.6401562690734863,0.3360087871551514,0.04455702379345894,-0.06418042629957199,-0.09936826676130295,-0.1655629128217697,-0.1529587656259537,-0.1085543408989906,-0.1085543408989906,-0.1662343144416809,-0.2595294117927551,-0.3054292500019073,-0.2752769589424133,-0.2857753336429596,-0.3192541301250458,-0.3423871695995331,-0.3870357275009155,-0.425977349281311,-0.5023346543312073,-0.491592139005661,-0.4169438779354095,-0.3772698044776917,-0.4121219515800476,-0.4687032699584961,-0.4202398657798767,-0.3880428373813629,-0.4673299491405487,-0.6086611747741699,-0.713492214679718,-0.7399212718009949,-0.7645191550254822,-0.8298898339271545,-0.7565233111381531,-0.5878475308418274,-0.4770042896270752,-0.4124576449394226,-0.3771782517433167,-0.3573412299156189,-0.4315927624702454,-0.4875026643276215,-0.4886318445205688,-0.4917447566986084,-0.5196996927261353,-0.6599322557449341,-0.6288644075393677,-0.4136784076690674,-0.1488082557916641,0.1404156684875488,0.2220831960439682,0.2034974247217178,0.05609302222728729,-0.2122257202863693,-0.4718161523342133,-0.5195165872573853,-0.2474135607481003,-0.09808649122714996,-0.189123198390007,-0.2967925071716309,-0.365489661693573,-0.3765679001808167,-0.2081057131290436,0.008117923513054848,0.1183812990784645,0.02179021574556828,-0.1532334387302399,-0.2482986003160477,-0.3932310044765472,-0.5315103530883789,-0.6566362380981445,-0.6105838418006897,-0.4487746953964233,-0.2862636148929596,-0.1895504593849182,-0.2947172522544861,-0.3987548351287842,-0.4764244556427002,-0.5526902079582214,-0.5157628059387207,-0.4355601668357849,-0.3946653604507446,-0.4243293702602386,-0.5537583827972412,-0.5772881507873535,-0.5851924419403076,-0.6711325645446777,-0.7409893870353699,-0.7790765166282654,-0.7266762256622314,-0.6475112438201904,-0.4875942170619965,-0.300057977437973,-0.2453077733516693,-0.4626300930976868,-0.8383739590644836,-1.000030517578125,-1.000030517578125,-1.000030517578125,-1.000030517578125,-1.000030517578125,-0.7387920618057251,-0.5522019267082214,-0.6027711033821106,-0.5899227857589722,-0.4998931884765625,-0.3501693904399872,-0.189153715968132,-0.1639149188995361,-0.1514938771724701,-0.1076387837529182,-0.1961119472980499,-0.3257851004600525,-0.3577074408531189,-0.3266701400279999,-0.3075655400753021,-0.3912167847156525,-0.3611865639686584,-0.2809534072875977,-0.2006897181272507,-0.04287850484251976,0.02716147340834141,-0.07876827567815781,-0.3461104035377502,-0.5318460464477539,-0.634723961353302,-0.8121585845947266,-0.8736533522605896,-0.5722830891609192,-0.2275460064411163,-0.07238990813493729,-0.1114536002278328,-0.2736594676971436,-0.2948698401451111,-0.2858974039554596,-0.3467818200588226,-0.4477065205574036,-0.3764458000659943,-0.2431104481220245,-0.2834559082984924,-0.2631610929965973,-0.1759697198867798,-0.1057771518826485,-0.09228797256946564,-0.06231879815459251,0.1098055988550186,0.1879940181970596,0.01635792106389999,-0.07345805317163467,0.02182073518633842,0.0157170332968235,-0.2442091107368469,-0.5016022324562073,-0.4322336614131927,-0.2609942853450775,-0.2164372652769089,-0.1575670689344406,0.08581805229187012,0.3694265484809875,0.4422132074832916,0.3223364949226379,0.1771904677152634,0.0952482670545578,-0.04263435676693916,-0.1544541716575623,-0.107058934867382,-0.1355327069759369,-0.4476149678230286,-0.7899105548858643,-0.765678882598877,-0.5141147971153259,-0.3264564871788025,-0.2680746018886566,-0.3801080286502838,-0.5182653069496155,-0.5920590758323669,-0.6367686986923218,-0.634784996509552,-0.5726187825202942,-0.5112766027450562,-0.6534318327903748,-0.8293405175209045,-0.7973265647888184,-0.8249152898788452,-0.8132877349853516,-0.574694037437439,-0.3761101067066193,-0.252052366733551,-0.208960235118866,-0.2477797716856003,-0.2229682356119156,-0.04947050288319588,0.2486648112535477,0.4361095130443573,0.5525681376457214,0.729819655418396,0.6788537502288818,0.3597521781921387,0.2299569696187973,0.3922544121742249,0.4976043105125427,0.2862941324710846,0.1447492837905884,0.2013306021690369,0.08001953363418579,-0.01730399578809738,0.007721182890236378,0.05978576093912125,0.1199987828731537,0.04986724629998207,-0.1249732971191406,-0.2453077733516693,-0.1849726885557175,-0.03421124815940857,0.0001831110566854477,0.05850398167967796,0.04330576583743095,-0.113376259803772,-0.1357463300228119,-0.1596423238515854,-0.2720725238323212,-0.4333323240280151,-0.3815424144268036,-0.1788994967937469,-0.1729789078235626,-0.2327646762132645,-0.3493453860282898,-0.4399242997169495,-0.4809717237949371,-0.5678579211235046,-0.4841456413269043,-0.3924375176429749,-0.447798103094101,-0.448561042547226,-0.5377971529960632,-0.5984374284744263,-0.5728324055671692,-0.6411023139953613,-0.7112643718719482,-0.7188634872436523,-0.7559129595756531,-0.9481185078620911,-1.000030517578125,-0.8052613735198975,-0.4994964301586151,-0.4920194149017334,-0.6740928292274475,-0.7018646597862244,-0.8886379599571228,-1.000030517578125,-0.843043327331543,-0.4667195677757263,-0.2743614017963409,-0.2359996289014816,-0.3495284914970398,-0.6183355450630188,-0.713614284992218,-0.7713858485221863,-0.6823633313179016,-0.5448164343833923,-0.4116947054862976,-0.3640858232975006,-0.5710318088531494,-0.5870235562324524,-0.3187353014945984,-0.2098757922649384,-0.378093808889389,-0.4286629855632782,-0.3700979650020599,-0.2986846566200256,-0.2597430348396301,-0.2229377180337906,-0.2247688174247742,-0.2921842038631439,-0.2155522257089615,-0.1798455715179443,-0.2170476466417313,-0.3923154473304749,-0.6467177271842957,-0.7755363583564758,-0.7224951982498169,-0.6280099153518677,-0.6533402800559998,-0.6149479746818542,-0.5941343307495117,-0.6147648692131042,-0.5962706208229065,-0.4662922918796539,-0.3412579596042633,-0.203894168138504,0.08352915942668915,0.204199343919754,0.09176915884017944,-0.0160832554101944,0.006134220398962498,-0.0790429413318634,-0.1516769975423813,-0.09646900743246078,-0.1787163913249969,-0.4290902316570282,-0.5937681198120117,-0.460524320602417,-0.4163945317268372,-0.3932615220546722,-0.2267220020294189,-0.1916562467813492,-0.2460402250289917,-0.3992126286029816,-0.5716422200202942,-0.52244633436203,-0.3928037285804749,-0.3085726499557495,-0.3806573748588562,-0.5857417583465576,-0.5685903429985046,-0.3865474462509155,-0.1720328330993652,-0.1425824761390686,-0.2147892713546753,-0.176122322678566,-0.1545762568712234,-0.1242103353142738,-0.2462233304977417,-0.3162633180618286,-0.1250343322753906,0.03057954646646976,0.0713827908039093,0.02191228978335857,-0.01519821770489216,0.1069673746824265,0.2075258642435074,0.2645954787731171,0.2251045256853104,0.09640797227621078,0.05871761217713356,-0.1146580427885056,-0.2615131139755249,-0.2529068887233734,-0.1627857238054276,-0.1771599501371384,-0.34736168384552,-0.173833429813385,-0.03656117618083954,-0.1506698876619339,-0.0950956791639328,0.03457747027277946,0.2446058541536331,0.2581560611724854,-0.05178990960121155,-0.2471083700656891,-0.3288979828357697,-0.2808923721313477,-0.1091952249407768,0.09118930995464325,0.2009643912315369,-0.04522843286395073,-0.2292550504207611,-0.02227851189672947,0.2428357750177383,0.3613391518592834,0.3600573837757111,0.4791406095027924,0.5786309242248535,0.1941282451152802,-0.2219916433095932,-0.2079836428165436,0.003936887718737125,0.0869472324848175,-0.05374309420585632,0.05887020379304886,0.239387184381485,0.191534161567688,0.1962950527667999,0.2477492541074753,0.3410443365573883,0.3603930771350861,0.3460798859596252,0.3195593059062958,0.2183294147253036,0.2249214202165604,0.2537919282913208,0.2860805094242096,0.4799035489559174,0.6035035252571106,0.5713980793952942,0.4080019593238831,0.2184209674596786,0.3564867079257965,0.5793328881263733,0.7325662970542908,0.8583330512046814,0.9271828532218933,0.7168492674827576,0.2641071677207947,0.1109653040766716,0.2448805272579193,0.5710012912750244,0.634418785572052,0.4467909932136536,0.365642249584198,0.1883297264575958,0.006683553569018841,-0.1093173027038574,-0.02072206884622574,0.0634174644947052,-0.0868251621723175,-0.2132023125886917,-0.2297128140926361,-0.2460707426071167,-0.2146977186203003,-0.03582873195409775,0.0313425101339817,-0.07855464518070221,-0.1968749016523361,-0.3797113001346588,-0.4764549732208252,-0.2016357928514481,0.003021332435309887,-0.1082186326384544,-0.1660817265510559,-0.2482680678367615,-0.3509933650493622,-0.3882870078086853,-0.224127933382988,-0.01528977323323488,-0.1576586216688156,-0.002929776906967163,0.1987975686788559,-0.08929716050624847,-0.3628345727920532,-0.4575640261173248,-0.1818597912788391,-0.1058076694607735,-0.1556749194860458,-0.06134220585227013,-0.2534257173538208,-0.2503128051757812,-0.156254768371582,-0.1451155096292496,-0.01266518142074347,0.09045686572790146,-0.01120029296725988,-0.1979735642671585,-0.4029358923435211,-0.3993957340717316,-0.3055513203144073,-0.2361217141151428,0.01806695759296417,-0.1074251532554626,-0.3740348517894745,-0.5923337340354919,-0.7097384333610535,-0.574388861656189,-0.5006256103515625,-0.4946134686470032,-0.5640125870704651,-0.5101779103279114,-0.4041871428489685,-0.5005645751953125,-0.6099429130554199,-0.3285927772521973,-0.1326029300689697,-0.4186224043369293,-0.5655690431594849,-0.335123747587204,-0.1949827522039413,-0.2765282094478607,-0.1495712101459503,-0.1115451529622078,-0.3620410859584808,-0.6397290229797363,-0.6824854016304016,-0.3642078936100006,-0.1568346172571182,0.125827819108963,0.430280476808548,0.2431714832782745,0.251686155796051,0.329905092716217,0.06662190705537796,0.05035554245114326,0.0316171757876873,0.005371257662773132,0.03802606463432312,-0.06909390538930893,-0.1250953674316406,-0.2979827225208282,-0.2894375324249268,-0.1590014398097992,-0.299783319234848,-0.1869869083166122,0.1704153567552567,-0.06802576035261154,-0.6465346217155457,-0.8906216621398926,-0.9280678629875183,-0.887508749961853,-0.5317850112915039,0.05316324532032013,0.1470686942338943,0.1400189250707626,0.4071474373340607,0.4658040106296539,0.3308206498622894,0.1369975954294205,0.1496932953596115,0.2898037731647491,0.4265266954898834,0.5082552433013916,0.2895290851593018,0.1583300232887268,0.3629566431045532,0.6198309063911438,0.7394024729728699,0.6013977527618408,0.448561042547226,0.3496810793876648,0.3420819640159607,0.5169225335121155,0.5602893233299255,0.5714896321296692,0.6017944812774658,0.539841890335083,0.4187139570713043,0.2648091018199921,0.2439039349555969,0.4061098098754883,0.5274208784103394,0.5728934407234192,0.6896877884864807,0.6625873446464539,0.4925076961517334,0.426221489906311,0.5921201109886169,0.730643630027771,0.6905728578567505,0.765953540802002,0.9323404431343079,0.9574266672134399,0.8541520237922668,1,1,1,1,0.7544785737991333,0.7976317405700684,0.5975524187088013,0.05801568552851677,-0.1480147689580917,0.1727042496204376,0.3020416796207428,0.0008850367739796638,-0.1344340294599533,-0.01937925443053246,0.04959257692098618,-0.1068758219480515,-0.2594988942146301,-0.1504867672920227,0.123599961400032,0.2031311988830566,0.1875057220458984,0.3581957519054413,0.7271034717559814,1,1,0.826532781124115,0.7830134034156799,0.5552842617034912,0.2382274866104126,0.335154265165329,0.7087618708610535,0.7853633165359497,0.8845484852790833,1,0.9996337890625,0.8520462512969971,0.634144127368927,0.7502670288085938,0.939878523349762,0.9765007495880127,1,0.9185155630111694,0.7867061495780945,0.7672658562660217,0.3808404803276062,-0.03628650680184364,0.008453627116978168,0.04931791126728058,-0.08392590284347534,-0.221533864736557,-0.1311685591936111,0.2121036350727081,0.3603015244007111,0.2923062741756439,0.07882931083440781,-0.009552293457090855,0.3440656661987305,0.5757011771202087,0.304208517074585,-0.02029480971395969,0.08819849044084549,0.4578081667423248,0.7398602366447449,0.9060029983520508,0.6876125335693359,0.3068330883979797,0.2597430348396301,0.430494099855423,0.5374004244804382,0.6046632528305054,0.8786584138870239,0.887112021446228,0.617603063583374,0.4352244734764099,0.4507278800010681,0.7762992978096008,0.9478743672370911,1,1,1,1,1,0.904721200466156,0.9364604353904724,1,1,0.4843287467956543,0.1064790785312653,0.1086458936333656,0.1302530020475388,-0.1424604058265686,-0.02719199284911156,0.4102298021316528,0.8043763637542725,0.9327372312545776,0.9496444463729858,0.99908447265625,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,0.9327677488327026,0.5515609979629517,0.5662099123001099,0.8716086149215698,1,0.7069002389907837,0.3443708717823029,0.5677358508110046,1,1,1,1,1,1,0.939054548740387,0.886410117149353,0.813]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>luger_9mm</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[-0.07568590342998505,-0.05087435618042946,-0.0320139154791832,-0.06503494083881378,-0.1063570082187653,-0.1092867851257324,-0.08261360228061676,-0.07412946224212646,-0.09753715991973877,-0.1270180344581604,-0.1571092903614044,-0.1902523934841156,-0.1924192011356354,-0.1619922518730164,-0.1333658844232559,-0.1397747695446014,-0.1352885514497757,-0.09152501076459885,-0.08062990009784698,-0.08154545724391937,-0.02755821496248245,0.03219702839851379,0.06711020320653915,0.108340710401535,0.09985656291246414,0.06183050200343132,0.07586901634931564,0.09048738330602646,0.08673360198736191,0.079256571829319,0.06106753647327423,0.06585894525051117,0.08627582341432571,0.08612323552370071,0.09363079071044922,0.1005890071392059,0.09076204895973206,0.07971435040235519,0.09170812368392944,0.1094698905944824,0.08169805258512497,0.06405834853649139,0.06982634961605072,0.07077242434024811,0.04812768846750259,0.01361125521361828,0.01626636646687984,0.04873805865645409,0.07428205013275146,0.08636738359928131,0.1116977483034134,0.1243629232048988,0.1273537427186966,0.1373638063669205,0.1241187751293182,0.09759819507598877,0.07498397678136826,0.06094546243548393,0.05859553813934326,0.05331583693623543,0.02874843589961529,0.002014221623539925,-0.01605273596942425,-0.02237006835639477,-0.02502517774701118,-0.0397351011633873,-0.05746635422110558,-0.07315286993980408,-0.08133182674646378,-0.06250190734863281,-0.05847346410155296,-0.09152501076459885,-0.0951567143201828,-0.07589953392744064,-0.05874812975525856,-0.05432294681668282,-0.05301064997911453,-0.06698812544345856,-0.09604174643754959,-0.1155430749058723,-0.128269299864769,-0.1117587834596634,-0.1137424856424332,-0.1555223315954208,-0.1772515028715134,-0.1768547594547272,-0.1960814297199249,-0.2146977186203003,-0.1781060248613358,-0.1249732971191406,-0.1204260364174843,-0.1367229223251343,-0.1617786139249802,-0.1853389143943787,-0.2103335708379745,-0.2254707515239716,-0.2170476466417313,-0.2030091285705566,-0.1871394962072372,-0.1997131258249283,-0.20657978951931,-0.1989501565694809,-0.1819818764925003,-0.1233558133244514,-0.04269539564847946,-0.004730368964374065,-0.008423108607530594,-0.01440473645925522,-0.0397656187415123,-0.04608295112848282,-0.03765984252095222,-0.02084414288401604,0.0004272591322660446,0.002105777151882648,-0.01376384776085615,-0.07748649269342422,-0.1064485609531403,-0.07544175535440445,-0.04446546733379364,-0.00436414685100317,0.003814813680946827,-0.06924650073051453,-0.1262550801038742,-0.08609271794557571,-0.02539139986038208,-0.002533036284148693,-0.007019257172942162,-0.02078310586512089,-0.03692739829421043,-0.04470961540937424,-0.03039643540978432,-0.002410962246358395,0.03521836176514626,0.0397961363196373,0.04504531994462013,0.05496383458375931,0.03527939692139626,0.03698843345046043,0.02551347389817238,-0.007110812701284885,-0.0555742047727108,-0.0875576063990593,-0.1041901931166649,-0.1051057502627373,-0.09714041650295258,-0.1348307728767395,-0.1478926986455917,-0.09927671402692795,-0.06222724169492722,-0.09558397531509399,-0.1362651437520981,-0.1745048314332962,-0.1963560879230499,-0.1809442490339279,-0.2285225987434387,-0.2916654050350189,-0.286812961101532,-0.2630390226840973,-0.2537919282913208,-0.2410962283611298,-0.2402722239494324,-0.2620319128036499,-0.2511978447437286,-0.2107303142547607,-0.1657155007123947,-0.1185949295759201,-0.08590960502624512,-0.08117923885583878,-0.0714438334107399,-0.02871791832149029,0.006714072078466415,0.03238013759255409,0.04980620741844177,0.07400738447904587,0.09460738301277161,0.1006195247173309,0.1176488548517227,0.1237220391631126,0.125888854265213,0.1390118151903152,0.1559800952672958,0.1650135815143585,0.1651661694049835,0.156315803527832,0.1619922518730164,0.1704458743333817,0.1668752133846283,0.1746879518032074,0.1775872111320496,0.1849116533994675,0.2008728235960007,0.2060609757900238,0.186346024274826,0.1594897359609604,0.1589404046535492,0.1601001024246216,0.1559800952672958,0.1675466150045395,0.1542405486106873,0.1129184886813164,0.09195227175951004,0.06570634990930557,0.03756828606128693,0.04983672499656677,0.05130161345005035,0.03619495406746864,0.06714072078466415,0.09942930191755295,0.07605212926864624,0.05783257633447647,0.07431256771087646,0.08996856957674026,0.09247108548879623,0.06964323669672012,0.05954161286354065,0.06118961051106453,0.02438428997993469,-0.03039643540978432,-0.06942960619926453,-0.07461775839328766,-0.1043733060359955,-0.1477095931768417,-0.1694082468748093,-0.2061220109462738,-0.2076174169778824,-0.1582384705543518,-0.07669301331043243,-0.04040650650858879,-0.06711020320653915,-0.04397717118263245,-0.01367229223251343,-0.04455702379345894,-0.05795465037226677,-0.01330607011914253,0.004272591322660446,-0.02029480971395969,-0.003601184114813805,0.02511673420667648,0.005737479776144028,-0.01504562515765429,-0.03912473097443581,-0.0715353861451149,-0.04989776387810707,-0.01818903163075447,-0.00634784996509552,-0.008026367984712124,-0.04022339731454849,-0.04272591322660446,-0.03424176946282387,-0.04211554303765297,-0.04831080138683319,-0.04913480207324028,-0.01181066315621138,0.0479750968515873,0.06494338810443878,0.02600177004933357,0.0138248847797513,0.031464584171772,0.02649006620049477,0.01129184849560261,0.01300088502466679,0.01889095827937126,0.04031495004892349,0.1035798192024231,0.1469161063432693,0.1662037968635559,0.2070986032485962,0.2386242300271988,0.2578814029693604,0.2666402161121368,0.2678304314613342,0.2758873403072357,0.2827845215797424,0.2782677710056305,0.2670980095863342,0.252418577671051,0.204138308763504,0.1667226105928421,0.113223671913147,0.007232886739075184,-0.08920560032129288,-0.113376259803772,-0.07660146057605743,-0.047883540391922,-0.0079348124563694,0.0317697674036026,0.04712057858705521,0.05743583664298058,0.08877834677696228,0.1416058838367462,0.1675466150045395,0.1543931365013123,0.140995517373085,0.1419110745191574,0.1580553650856018,0.1882992088794708,0.206671342253685,0.2166509032249451,0.1918088346719742,0.1487777382135391,0.1727652847766876,0.2112186104059219,0.1950132697820663,0.1707205474376678,0.1526841074228287,0.1170690059661865,0.1058687120676041,0.09775078296661377,0.0716269388794899,0.05603198334574699,0.02856532484292984,0.05011139437556267,0.1027558222413063,0.1080660447478294,0.09311196953058243,0.0399487279355526,-0.01052888575941324,0.008850367739796638,0.01431318093091249,-0.02716147340834141,-0.06848353892564774,-0.0552385039627552,-0.0157170332968235,-0.05294961482286453,-0.0954008623957634,-0.08868678659200668,-0.079348124563694,-0.06628620624542236,-0.06030457466840744,-0.0558488741517067,-0.04147465527057648,-0.0158696249127388,0.01873836480081081,0.03079317696392536,0.0317392498254776,0.08816797286272049,0.1369365453720093,0.1090426370501518,0.07632679492235184,0.07785271853208542,0.07568590342998505,0.0393688790500164,0.02047792077064514,0.009674367494881153,-0.06491287052631378,-0.107272557914257,-0.07574693858623505,-0.07559435069561005,-0.0710165724158287,-0.02630695514380932,0.01873836480081081,0.02896206639707088,0.003692739643156528,-0.0236823633313179,-0.0473952442407608,-0.05606250092387199,-0.04165776446461678,-0.04553361609578133,-0.07721182703971863,-0.09137241542339325,-0.1128574460744858,-0.1139255985617638,-0.09958189725875854,-0.1188390776515007,-0.1150852963328362,-0.08987700939178467,-0.09579759836196899,-0.09302041679620743,-0.0557268001139164,-0.009094515815377235,0.05365154147148132,0.09060945361852646,0.07324442267417908,0.02664265967905521,0.02175969816744328,0.04937895014882088,0.07193212956190109,0.09097567945718765,0.06268502026796341,-0.004516739398241043,-0.07019257545471191,-0.07834101468324661,-0.04190191254019737,-0.009399700909852982,-0.008239997550845146,-0.03720206394791603,-0.03747672960162163,0.002594073303043842,0.04535050690174103,0.05606250092387199,0.07278664410114288,0.0874355286359787,0.09329508244991302,0.1124912276864052,0.05359050258994102,-0.009277626872062683,0.003814813680946827,-0.01348918117582798,-0.04693746939301491,-0.0318002887070179,-0.01760918088257313,-0.01452681049704552,-0.006775109097361565,-0.02841273322701454,-0.06485183537006378,-0.0874965637922287,-0.07257301360368729,-0.0876796767115593,-0.1206091493368149,-0.09384441375732422,-0.09598071128129959,-0.1492965519428253,-0.1816766858100891,-0.1619617342948914,-0.1723685413599014,-0.2121646851301193,-0.1947080940008163,-0.176152840256691,-0.191167950630188,-0.2103030532598495,-0.2230597883462906,-0.2543717622756958,-0.2969145774841309,-0.2909634709358215,-0.256996363401413,-0.2357249706983566,-0.2409436255693436,-0.2503738403320312,-0.2175664603710175,-0.1575975865125656,-0.06903287023305893,-0.0135807367041707,-0.008301034569740295,0.01852473616600037,0.05349894613027573,0.08178960531949997,0.06308175623416901,0.02914517745375633,0.02804651111364365,0.05121006071567535,0.05441450327634811,0.06247138977050781,0.0875881239771843,0.06814783066511154,0.04257332161068916,-0.006714072078466415,-0.006195257417857647,0.009033478796482086,-0.05755791068077087,-0.0869167149066925,-0.09082308411598206,-0.1172826290130615,-0.08847315609455109,-0.03640858083963394,-0.07599108666181564,-0.145786926150322,-0.1296121031045914,-0.06494338810443878,-0.003936887718737125,0.0713827908039093,0.09329508244991302,0.02929776906967163,-0.003845332190394402,0.03061006590723991,0.03415021300315857,0.009613330475986004,0.02847377024590969,0.05298013240098953,0.06122013181447983,0.07855464518070221,0.09698782116174698,0.07010101526975632,0.04168828576803207,0.1017181947827339,0.1325113624334335,0.07800531387329102,0.08816797286272049,0.1431928426027298,0.1571092903614044,0.1523483991622925,0.1018402650952339,0.0278939176350832,0.009552293457090855,0.01235999632626772,0.008270516060292721,0.02514725178480148,0.06744590401649475,0.07214576005935669,0.002624591812491417,-0.03830073028802872,-0.04486221075057983,-0.06158635392785072,-0.05392620712518692,-0.03564561903476715,-0.04809717088937759,-0.05737479776144028,-0.05633717030286789,-0.0476088747382164,-0.02713095583021641,-0.01831110566854477,0.001129184849560261,0.00912503432482481,0.03295999020338058,0.05423139035701752,0.01669362559914589,-0.007202368229627609,-0.03512680530548096,-0.07889034599065781,-0.1042817458510399,-0.06915494054555893,0.003601184114813805,-0.02658162266016006,-0.08206427097320557,-0.06582842767238617,-0.0277718435972929,-0.006256294436752796,0.003631702624261379,0.009765923023223877,0.0397961363196373,0.09253212064504623,0.0877101942896843,0.05224768817424774,0.06656087189912796,0.09994811564683914,0.09692678600549698,0.06582842767238617,0.03518784046173096,0.04913480207324028,0.09231849014759064,0.1167943328619003,0.1176183372735977,0.1102023348212242,0.1061738952994347,0.07333597540855408,0.03076265752315521,0.01452681049704552,0.02978606522083282,0.04406872764229774,0.0156254768371582,0.03695791587233543,0.05679494515061378,0.005920590832829475,0.003906369209289551,0.001403851434588432,-0.04809717088937759,-0.02969451062381268,0.01782280951738358,0.0007019257172942162,-0.02539139986038208,-0.03424176946282387,-0.05151524394750595,-0.06244087219238281,-0.05114902183413506,-0.02166814170777798,0.002105777151882648,0.00595110934227705,-0.02227851189672947,-0.01998962461948395,0.0235602892935276,0.01791436597704887,0.003387554548680782,-0.01617481000721455,-0.06747642159461975,-0.05453657731413841,0.007812738418579102,0.01123081147670746,-0.0120242927223444,0.006653035059571266,0.04446546733379364,0.01016266364604235,-0.04062013700604439,-0.03332621231675148,-0.03415021300315857,-0.02432325296103954,-0.03549302741885185,-0.04324472695589066,-0.04474013671278954,-0.0953703448176384,-0.1036713793873787,-0.0875270888209343,-0.0789819061756134,-0.06146427989006042,-0.04968413338065147,-0.03024384379386902,0.007263405248522758,0.03103732503950596,0.04141361638903618,0.05206457898020744,0.08630634844303131,0.1186254471540451,0.08990752696990967,0.06909390538930893,0.03057954646646976,-0.01086458936333656,0.02212592028081417,0.02459791861474514,0.009857478551566601,0.04065065458416939,0.04669332131743431,0.02459791861474514,0.04535050690174103,0.06286813318729401,0.03527939692139626,0.0556962788105011,0.09839167445898056,0.05600146576762199,-0.027405621483922,-0.02035584673285484,0.004943998530507088,0.005829035304486752,0.03216651082038879,0.009582811966538429,-0.04043702408671379,-0.04852443188428879,0.02807702869176865,0.09692678600549698,0.09183019399642944,0.1004669368267059,0.07858516275882721,0.05401776358485222,0.06485183537006378,0.05978576093912125,0.08362071961164474,0.06390576064586639,0.04403821006417274,0.07309182733297348,0.04565569013357162,0.04589983820915222,0.07220679521560669,0.08044679462909698,0.05386516824364662,0.01669362559914589,0.03805658221244812,0.06534013152122498,0.08297982811927795,0.07055879384279251,0.04223761707544327,0.04339732229709625,0.04266487807035446,0.0475783571600914,0.06616412848234177,0.03512680530548096,-0.01712088473141193,0.01138340402394533,0.06909390538930893,0.1053804159164429,0.1074251532554626,0.07763908803462982,0.05972472205758095,0.02447584457695484,0.05432294681668282,0.05853450298309326,-0.0102237006649375,-0.01895199529826641,-0.02505569718778133,0.02359080873429775,0.08676411956548691,0.09750663489103317,0.09326456487178802,0.01940977200865746,-0.04333628341555595,-0.06207465007901192,-0.07461775839328766,-0.05853450298309326,-0.05462813377380371,-0.03448591753840446,-0.02194280922412872,-0.05990783497691154,-0.09192175418138504,-0.07342753559350967,-0.05725272372364998,-0.09668263792991638,-0.08157597482204437,-0.03045747242867947,-0.01693777367472649,-0.03488265722990036,-0.06625568121671677,-0.05255287513136864,-0.02291940152645111,-0.001709036529064178,0.01342814415693283,0.0320444367825985,0.02215643785893917,0.001495406962931156,0.01284829247742891,-0.00912503432482481,-0.004882961511611938,0.04107791557908058,0.03530991449952126,-0.005035554058849812,-0.00357066560536623,0.01770073547959328,0.01538132876157761,0.02273629046976566,0.01791436597704887,0.01416058838367462,-0.005523850210011005,-0.03231910243630409,0.001770073547959328,0.01031525619328022,-0.001129184849560261,0.00833155307918787,0.00277718435972929,0.02099673449993134,0.06179998070001602,0.06476027518510818,0.06079287081956863,0.08001953363418579,0.06601153314113617,0.01446577347815037,0.002014221623539925,0.008636738173663616,-0.04837183654308319,-0.04626606032252312,-0.03118991665542126,-0.07196264714002609,-0.05215613171458244,-0.0559404268860817,-0.08221686631441116,-0.1049226373434067,-0.1297341883182526,-0.1147190779447556,-0.09378337860107422,-0.1157261878252029,-0.1295205503702164,-0.0711691677570343,-0.02728354744613171,0.008789330720901489,0.04220709949731827,0.002349925227463245,-0.06796471774578094,-0.1179235205054283,-0.1484420299530029,-0.14127017557621,-0.1385235190391541,-0.1474959552288055,-0.1334269195795059,-0.1086458936333656,-0.07031464576721191,-0.08407849073410034,-0.07333597540855408,0.01617481000721455,0.07492294162511826,0.05743583664298058,0.00357066560536623,0.0138248847797513,0.007263405248522758,-0.0238959938287735,0.002960295416414738,-0.02728354744613171,-0.06299020349979401,-0.04626606032252312,-0.04821924492716789,-0.05227820575237274,-0.06445509195327759,-0.06485183537006378,-0.04507583752274513,-0.02533036284148693,-0.006836146116256714,-0.005829035304486752,-0.006775109097361565,0.006103701889514923,0.01248207036405802,0.01379436627030373,0.04824976250529289,0.08255256712436676,0.06256294250488281,0.04638813436031342,0.07544175535440445,0.07058931142091751,0.04654072597622871,0.03418073058128357,0.01492355111986399,0.01336710713803768,0.04287850484251976,0.09836115688085556,0.09460738301277161,0.06613361090421677,0.1023285612463951,0.1011078208684921,0.06018250063061714,0.03915524855256081,0.008514664135873318,-0.02047792077064514,-0.0717490166425705,-0.123538926243782,-0.1168248578906059,-0.04062013700604439,-0.02572710439562798,-0.0790429413318634,-0.04852443188428879,-0.07315286993980408,-0.1543626189231873,-0.140995517373085,-0.0953703448176384,-0.06125064939260483,-0.03646961972117424,-0.03830073028802872,-0.03485213965177536,-0.01126132998615503,-0.0315561406314373,-0.09454634040594101,-0.1388286948204041,-0.06143375858664513,0.03485213965177536,0.007782219909131527,-0.01974547654390335,-0.009613330475986004,-0.004303109832108021,-0.0395519882440567,-0.02941984310746193,0.02136295661330223,0.05117953941226006,0.06567583233118057,0.0235297717154026,0.01879940181970596,0.05783257633447647,0.06448560953140259,0.07513657212257385,0.1113925576210022,0.08493301272392273,0.03567613661289215,0.02529984526336193,0.003509628586471081,-0.02127140201628208,-0.02856532484292984,0.01443525496870279,0.07516708970069885,0.125888854265213,0.1594287008047104,0.1406292915344238,0.1384014338254929,0.1465193629264832,0.110812708735466,0.08648945391178131,0.1224097386002541,0.1425519585609436,0.09149449318647385,0.06283760815858841,0.06717123836278915,0.05954161286354065,0.05124057829380035,0.06021301820874214,0.07647938281297684,0.05160680040717125,0.02996917627751827,0.0397961363196373,-0.01916562393307686,-0.1055330038070679,-0.1223181858658791,-0.07623523473739624,0.002044740132987499,0.0480056144297123,0.01791436597704887,-0.07055879384279251,-0.1003753766417503,-0.04034547135233879,0.02636799216270447,0.0236823633313179,-0.06100650131702423,-0.1004364117980003,-0.07727286964654922,-0.04062013700604439,-0.04242072999477386,-0.1020233780145645,-0.0954008623957634,-0.07324442267417908,-0.07196264714002609,-0.01770073547959328,-0.002044740132987499,0.009094515815377235,0.01474044006317854,-0.03747672960162163,-0.02237006835639477,-0.01535081025213003,-0.08188115805387497,-0.1077608540654182,-0.09732352942228317,-0.08648945391178131,-0.08148442208766937,-0.09656056761741638,-0.08404797315597534,-0.05182043090462685,-0.05240027979016304,-0.07617419958114624,-0.08795434236526489,-0.06680501997470856,-0.01077303383499384,0.03509628772735596,0.04513687640428543,0.04583880305290222,0.05389568954706192,0.08798485994338989,0.07269509136676788,0.06723227351903915,0.1055330038070679,0.1317789256572723,0.1765190660953522,0.1991332769393921,0.1789605468511581,0.1300393640995026,0.0873134583234787,0.03250221163034439,0.02316354960203171,0.04998932033777237,0.03711050748825073,0.0555436871945858,0.07565538585186005,0.08423108607530594,0.06430249661207199,0.03265480697154999,0.01901303231716156,0.00912503432482481,0.01794488355517387,-0.02932828851044178,-0.09344767779111862,-0.1061128601431847,-0.07000946253538132,-0.08365123718976974,-0.1241493001580238,-0.06579791009426117,-0.0239265114068985,0.0001220740377902985,0.004181035794317722,-0.04309213533997536,-0.07809686660766602,-0.07675404846668243,-0.002502517774701118,0.0714438334107399,0.1126438155770302,0.125980406999588,0.09006012231111526,0.01239051483571529,-0.03454695269465446,-0.03271584212779999,-0.05398724228143692,-0.04254280403256416,-0.005829035304486752,0.009308145381510258,0.02725302986800671,0.08255256712436676,0.1028473749756813,0.1170384809374809,0.1605578809976578,0.09991759806871414,0.0317087322473526,0.03506576642394066,0.04455702379345894,0.04345835745334625,0.04629657790064812,0.001129184849560261,-0.08273568004369736,-0.1089205592870712,-0.09146397560834885,-0.06711020320653915,-0.09817804396152496,-0.1538132876157761,-0.1615649908781052,-0.1056855991482735,-0.04806665331125259,-0.03723258152604103,-0.01843317970633507,-0.03512680530548096,-0.06582842767238617,-0.06295968592166901,-0.02441480755805969,-0.007354960776865482,-0.01931821741163731,0.003936887718737125,-0.01998962461948395,-0.04431287571787834,-0.0634174644947052,-0.1032441183924675,-0.09790337830781937,-0.07995849847793579,-0.05194250494241714,-0.05227820575237274,-0.04861598461866379,-0.003936887718737125,0.05209509655833244,0.06964323669672012,0.05740531533956528,0.06689657270908356,0.06109805777668953,0.08078249543905258,0.1270790696144104,0.143742173910141,0.128604993224144,0.1190832257270813,0.1078829318284988,0.08325449377298355,0.0873134583234787,0.1082186326384544,0.1322367042303085,0.1109653040766716,0.0951872318983078,0.1625110656023026,0.143498033285141,0.07757805287837982,0.1018707826733589,0.1298257410526276,0.1196630746126175,0.08545182645320892,0.03387554734945297,0.0121463667601347,0.04046754539012909,0.0476699136197567,0.04995879903435707,0.0790429413318634,0.0632343515753746,0.02932828851044178,0.03375347331166267,0.04336680099368095,0.0872524157166481,0.07611316442489624,0.03747672960162163,0.0634784996509552,0.007415997795760632,-0.05081331729888916,-0.04586932063102722,-0.04910428076982498,-0.09414960443973541,-0.1426740288734436,-0.1350444108247757,-0.1297036707401276,-0.07757805287837982,-0.01782280951738358,-0.01559495832771063,-0.02883999235928059,-0.04284798726439476,-0.01147495955228806,0.02188177220523357,0.02450636401772499,0.0200811792165041,0.008362071588635445,-0.03424176946282387,-0.04855494946241379,-0.01852473616600037,-0.01440473645925522,0.007843256928026676,0.05645924434065819,0.06189153715968132,0.01229895930737257,0.004211554303765297,-0.003051850944757462,0.01849421672523022,0.07617419958114624,0.05355998501181602,-0.004821924492716789,-0.04467909783124924,0.031434066593647,0.110934779047966,0.05105746537446976,-0.01336710713803768,-0.05731376260519028,-0.07400738447904587,-0.02682577073574066,-0.03283791616559029,-0.079439677298069,-0.1197851523756981,-0.1840266138315201,-0.2160405218601227,-0.2171086817979813,-0.1406598091125488,-0.05340739339590073,-0.0868251621723175,-0.1354716569185257,-0.1240577399730682,-0.03854487836360931,-0.004242072813212872,-0.004150517284870148,0.08896145224571228,0.1313211470842361,0.09390545636415482,0.0949430838227272,0.1319925487041473,0.1334269195795059,0.1540574431419373,0.1918088346719742,0.1292764097452164,0.02044740132987499,-0.02755821496248245,-0.03341776877641678,0.001709036529064178,0.07055879384279251,0.1114841178059578,0.125949889421463,0.09686575084924698,0.04129154235124588,-0.0162053294479847,-0.0241706594824791,0.02685628831386566,0.02050843834877014,0.04876857995986938,0.1019013002514839,0.06869716197252274,0.07980590313673019,0.08944974839687347,0.05862605571746826,0.05117953941226006,-0.009002960287034512,-0.02954191714525223,0.02826013974845409,0.06753746420145035,0.0476393923163414,-0.01538132876157761,-0.02240058593451977,-0.01171910762786865,-0.02981658466160297,-0.03253273293375969,-0.006897183135151863,-0.02258369699120522,-0.04709006100893021,-0.03006073273718357,-0.03482161834836006,-0.0276497695595026,-0.03442487865686417,-0.0559404268860817,-0.07495345920324326,-0.04922635480761528,0.05648976191878319,0.1204260364174843,0.09668263792991638,0.08355967700481415,0.1224097386002541,0.1039460450410843,0.02908414043486118,-0.01779229193925858,0.01315347757190466,0.0558183528482914,0.0717795342206955,0.09405804425477982,0.07196264714002609,0.0475478395819664,0.03097628802061081,-0.002533036284148693,-0.001373332925140858,0.0156254768371582,-0.02468947507441044,-0.08493301272392273,-0.09155552834272385,-0.1323282569646835,-0.2334055602550507,-0.2481765151023865,-0.1700491309165955,-0.1050447076559067,-0.08505508303642273,-0.07025361061096191,-0.08944974839687347,-0.1161534488201141,-0.0791344940662384,-0.06918545812368393,-0.08337657153606415,-0.05111850425601006,-0.001373332925140858,0.04434339329600334,0.02322458662092686,-0.0006103701889514923,0.05706961452960968,0.09164708107709885,0.1145054474473,0.128604993224144,0.1212195232510567,0.1344645470380783,0.07412946224212646,0.02313303016126156,0.05285805836319923,0.02011169865727425,-0.02261421643197536,0.01821955107152462,0.1101718172430992,0.1802423149347305,0.1647083908319473,0.1090426370501518,0.03408917412161827,-0.09411908686161041,-0.1798760890960693,-0.203985720872879,-0.1720328330993652,-0.1067537441849709,-0.05996887013316154,-0.04849391058087349,-0.08838160336017609,-0.07660146057605743,-0.04522843286395073,-0.06054872274398804,-0.09848322719335556,-0.1007110849022865,-0.1154210045933723,-0.2269051223993301,-0.1988586038351059,-0.09826960414648056,-0.1275673657655716,-0.1567125469446182,-0.1702627688646317,-0.1591845452785492,-0.1268654465675354,-0.08468886464834213,-0.05627613142132759,-0.07635731250047684,-0.06814783066511154,0.002960295416414738,0.039704579859972,0.05111850425601006,0.08648945391178131,0.08819849044084549,0.07971435040235519,0.07712027430534363,0.08105716109275818,0.05484176054596901,-0.0079348124563694,-0.05966368690133095,-0.01348918117582798,0.04480117186903954,-0.02371288277208805,-0.02783288061618805,0.00119022186845541,-0.007507553324103355,-0.01617481000721455,-0.07443464547395706,-0.09253212064504623,-0.07980590313673019,-0.05319376289844513,-0.06418042629957199,-0.141056552529335,-0.1879024654626846,-0.1733756512403488,-0.08185064047574997,-0.006134220398962498,-0.006897183135151863,-0.03357036039233208,-0.03585924953222275,-0.05847346410155296,-0.04840235784649849,0.05664235353469849,0.08294931054115295,0.07983642071485519,0.08578752726316452,0.05175939202308655,0.0320749543607235,0.04821924492716789,0.07617419958114624,0.04049806296825409,-0.03045747242867947,-0.04886013269424438,0.01498458813875914,0.01043733023107052,-0.03607288002967834,0.02304147556424141,0.1262245625257492,0.1630909144878387,0.08130130916833878,0.001556443981826305,-0.0119022186845541,-0.03759880363941193,-0.0559099093079567,0.0003662221133708954,0.04666280001401901,-0.00674459058791399,-0.04138309881091118,0.02972502820193768,0.04031495004892349,0.0116580706089735,0.007568590342998505,0.006591998040676117,0.009094515815377235,-0.1014740467071533,-0.1751457303762436,-0.1427960991859436,-0.09042634069919586,-0.03076265752315521,0.01330607011914253,0.01367229223251343,-0.03872798755764961,-0.06802576035261154,-0.07583849877119064,-0.03848383948206902,0.02923673205077648,0.05035554245114326,0.05194250494241714,0.07660146057605743,0.1042817458510399,0.03698843345046043,-0.01461836602538824,0.03726309910416603,0.06128116697072983,0.02407910488545895,-0.009033478796482086,0.007629627361893654,0.002533036284148693,-0.04486221075057983,-0.06613361090421677,-0.02117984555661678,-0.004455702379345894,0.0157170332968235,0.06735435128211975,0.06949064880609512,0.04486221075057983,-0.01116977445781231,-0.04321420937776566,-0.03317362070083618,0.04217658191919327,0.1249122619628906,0.1211279630661011,0.07721182703971863,0.04809717088937759,0.03253273293375969,0.00436414685100317,0.008026367984712124,-0.01281777396798134,-0.06451612710952759,-0.1011078208684921,-0.1367229223251343,-0.1397747695446014,-0.09582812339067459,-0.005737479776144028,0.05294961482286453,0.01709036529064178,-0.01797540299594402,-0.001403851434588432,-0.02294991910457611,-0.02420117892324924,0.03762932121753693,0.08362071961164474,0.07559435069561005,0.08273568004369736,0.1105075255036354,0.06912442296743393,0.05801568552851677,0.04983672499656677,-0.01556443981826305,-0.09979552775621414,-0.1330301761627197,-0.08606220036745071,-0.05877865105867386,-0.07000946253538132,-0.02410962246358395,0.08243049681186676,0.09451582282781601,0.02258369699120522,0.02002014219760895,0.0633869469165802,0.03125095367431641,0.05096591264009476,0.08862575143575668,0.07003998011350632,0.1091952249407768,0.1565904766321182,0.1647694259881973,0.1669057309627533,0.203955203294754,0.1952879428863525,0.1594287008047104,0.1550950706005096,0.1469771414995193,0.1399578899145126,0.1720938682556152,0.2130191922187805,0.1632740199565887,0.1378826200962067,0.1968443840742111,0.2333445250988007,0.2353282272815704,0.1905575692653656,0.1142002642154694,0.08239997923374176,0.05911435186862946,0.04699850454926491,0.07556383311748505,0.02099673449993134,-0.03012176975607872,-0.05459761247038841,-0.1168248578906059,-0.1637623161077499,-0.2245246767997742,-0.256508082151413,-0.256904810667038,-0.2592547237873077,-0.2143314927816391,-0.1223487034440041,-0.08105716109275818,-0.04864650592207909,-0.01339762564748526,-0.06991790235042572,-0.09833063930273056,-0.01159703359007835,0.02026429027318954,0.002685628831386566,0.04174932092428207,0.1011993810534477,0.171208843588829,0.17361980676651,0.1377605497837067,0.1172215938568115,0.1099581867456436,0.1130405589938164,0.05505539104342461,0.05966368690133095,0.1117282658815384,0.1185949295759201,0.1370586305856705,0.1498458832502365,0.1150852963328362,0.0871608629822731,0.1532944738864899,0.2093264609575272,0.1935178637504578,0.156285285949707,0.1377910673618317,0.1406292915344238,0.1329691410064697,0.1348002552986145,0.1239661872386932,0.07843256741762161,0.004028443247079849,-0.05294961482286453,-0.03436384350061417,0.05877865105867386,0.1348002552986145,0.1741386204957962,0.2157353460788727,0.2035889774560928,0.2032532691955566,0.1925412714481354,0.09787286072969437,0.01812799461185932,0.01614429242908955,-0.04107791557908058,-0.1266823261976242,-0.0872524157166481,-0.07043672353029251,-0.1189001128077507,-0.08499404788017273,-0.02456740103662014,-0.01538132876157761,0.02945036254823208,0.09298989921808243,0.07068087160587311,0.02490310370922089,0.02517777122557163,0.01864681020379066,-0.01361125521361828,-0.01251258887350559,-0.01373332925140858,-0.04626606032252312,-0.03286843374371529,-0.03338725119829178,-0.04901272803544998,0.005829035304486752,0.1074556708335876,0.1192663386464119,0.03579821065068245,-0.02624591812491417,-0.0200811792165041,0.05371257662773132,0.0713522732257843,0.04950102418661118,0.07712027430534363,0.1219519674777985,0.1416974365711212,0.1021759733557701,0.01220740377902985,-0.04846339300274849,-0.05108798667788506,-0.05758842825889587,-0.03064058348536491,-0.02386547438800335,-0.07739493995904922,-0.09311196953058243,-0.1318704783916473,-0.1577501744031906,-0.1233558133244514,-0.1173741891980171,-0.1211584806442261,-0.1011688560247421,-0.08804590255022049,-0.1339762508869171,-0.1754509061574936,-0.1844538748264313,-0.1703238040208817,-0.1301309317350388,-0.1271401047706604,-0.130710780620575,-0.1476180255413055,-0.108279675245285,0.03707998991012573,0.1064485609531403,0.03836176544427872,-0.007232886739075184,-0.0277718435972929,-0.07660146057605743,-0.03238013759255409,0.0316476933658123,-0.01950132846832275,-0.0473342090845108,0.05600146576762199,0.1521652936935425,0.1559190601110458,0.1493881046772003,0.09973449259996414,0.02902310341596603,0.04870754107832909,0.09314249455928802,0.1264381855726242,0.1139866337180138,0.07782220095396042,0.1100192293524742,0.05951109528541565,-0.03021332435309887,-0.01470992155373096,0.06524857133626938,0.1548203974962234,0.1779229044914246,0.1734366863965988,0.1422162503004074,0.1053498983383179,0.07461775839328766,0.079256571829319,0.1581774353981018,0.1723685413599014,0.1566820293664932,0.2056337147951126,0.1831720918416977,0.1184728518128395,0.09161656349897385,0.07638783007860184,0.07986693829298019,0.001617481000721455,-0.02499466016888618,0.1051362678408623,0.1537522524595261,0.1250648498535156,0.1231116652488708,0.07431256771087646,0.06888027489185333,0.1405987739562988,0.143772691488266,0.1103854477405548,0.1496017277240753,0.191564679145813,0.09045686572790146,0.009369182400405407,0.02917569503188133,-0.01840266212821007,-0.1052888557314873,-0.1651356518268585,-0.1589709222316742,-0.06616412848234177,-0.03695791587233543,-0.09668263792991638,-0.1180150732398033,-0.09707938134670258,-0.04251228272914886,-0.0551164299249649,-0.1159703359007835,-0.1289712190628052,-0.06027405709028244,0.0558793917298317,0.009887997061014175,-0.08993804454803467,-0.1196630746126175,-0.06283760815858841,0.04910428076982498,-0.05304117128252983,-0.1553392112255096,-0.1493270695209503,-0.140934482216835,-0.0633564293384552,-0.09298989921808243,-0.08880886435508728,0.007599108852446079,0.0159611813724041,-0.03918576613068581,-0.06195257604122162,-0.01501510664820671,0.03057954646646976,0.01617481000721455,-0.008148442022502422,0.0117801446467638,0.008117923513054848,-0.02240058593451977,0.01037629321217537,0.09747611731290817,0.1019623428583145,0.1021759733557701,0.1069368571043015,0.04138309881091118,0.09057893604040146,0.1423383355140686,0.0873439759016037,0.06488235294818878,0.005584887228906155,0.0160832554101944,0.07251197844743729,0.03054902888834476,0.04577776417136192,0.0316782146692276,0.01110873743891716,0.03537095338106155,0.03509628772735596,0.06839197874069214,0.09903256595134735,0.1452986299991608,0.1244544833898544,0.0201727356761694,-0.01174962613731623,0.09320352971553802,0.1904049813747406,0.1678823232650757,0.1198461875319481,0.09332560002803802,0.04910428076982498,-0.02954191714525223,-0.0795617550611496,-0.07708975672721863,-0.06988738477230072,-0.07812738418579102,-0.01861629076302052,0.0321359895169735,-0.007690664380788803,-0.05914487317204475,-0.08996856957674026,-0.08621478825807571,-0.07876827567815781,-0.07660146057605743,-0.09045686572790146,-0.1387981772422791,-0.1944029033184052,-0.2132633477449417,-0.2511978447437286,-0.3093356192111969,-0.3018585741519928,-0.2715231776237488,-0.2532120645046234,-0.2526017129421234,-0.2700583040714264,-0.2851649522781372,-0.304391622543335,-0.2175664603710175,-0.08783227205276489,-0.03042695485055447,-0.04614398628473282,-0.09939878433942795,-0.06286813318729401,-0.0392468050122261,-0.01474044006317854,0.03860591351985931,-0.003357036039233208,-0.04492324590682983,-0.06164738908410072,-0.08542130887508392,-0.0198370311409235,0.03030488081276417,0.05505539104342461,0.09091463685035706,0.08288827538490295,0.08822900801897049,0.05182043090462685,0.01120029296725988,-0.05298013240098953,-0.08239997923374176,-0.06582842767238617,-0.1149632260203362,-0.02557451091706753,0.1001007109880447,0.0870387926697731,0.04556413367390633,-0.01092562638223171,-0.01528977323323488,0.05789361149072647,0.08221686631441116,0.1113620400428772,0.1099581867456436,0.04345835745334625,0.06671345978975296,0.1329691410064697,0.1766411364078522,0.2055421620607376,0.2270271927118301,0.2486648112535477,0.2447584420442581,0.2582476139068604,0.3015228807926178,0.3032319247722626,0.3026825785636902,0.3285622596740723,0.3252662718296051,0.3258461356163025,0.3429670035839081,0.3498947024345398,0.3215430080890656,0.2308114916086197,0.1798150539398193,0.2378307431936264,0.3202612400054932,0.3038422763347626,0.236732080578804,0.171361431479454,0.1111789271235466,0.1178319677710533,0.05398724228143692,-0.03228858485817909,0.04290902614593506,0.1080050021409988,0.02938932552933693,-0.05307168886065483,-0.09622485935688019,-0.1015045642852783,-0.07037568092346191,-0.07867671549320221,-0.079439677298069,-0.09283730387687683,-0.1581469178199768,-0.2162541598081589,-0.2526017129421234,-0.1870174258947372,-0.1374858915805817,-0.1531418859958649,-0.0950041189789772,-0.09302041679620743,-0.09173864126205444,-0.04181035980582237,-0.0195928830653429,-0.01339762564748526,-0.08084353059530258,-0.1793267577886581,-0.2316049635410309,-0.236915186047554,-0.2232428938150406,-0.1516159623861313,-0.08908353000879288,-0.1717886924743652,-0.2914822697639465,-0.3196203410625458,-0.2944425940513611,-0.2890102863311768,-0.2851649522781372,-0.2800988852977753,-0.2742393314838409,-0.2508926689624786,-0.2060304582118988,-0.2176580131053925,-0.2942594587802887,-0.2838831841945648,-0.2451246678829193,-0.1905880868434906,-0.1810663193464279,-0.2035584598779678,-0.1683401018381119,-0.1908627599477768,-0.1704458743333817,-0.1476180255413055,-0.1778923869132996,-0.1757560968399048,-0.08182012289762497,0.08236945420503616,0.1750846952199936,0.1716666221618652,0.09152501076459885,0.06140324100852013,0.05734428018331528,0.0141911068931222,-0.002166814170777798,0.05279702320694923,0.1126743406057358,0.07614368200302124,0.06576738506555557,0.09283730387687683,0.03842280432581902,-0.04690694808959961,-0.06506546586751938,-0.06579791009426117,-0.05279702320694923,-0.007415997795760632,0.004211554303765297,0.0115359965711832,0.01351969968527555,0.08096560835838318,0.1369975954294205,0.124759666621685,0.1456038057804108,0.1482284069061279,0.1856746077537537,0.2045045346021652,0.1546067744493484,0.08993804454803467,0.1220130026340485,0.1629993617534637,0.03793450817465782,0.02273629046976566,0.03326517716050148,-0.04617450386285782,-0.007599108852446079,-0.02533036284148693,-0.09295938163995743,-0.06717123836278915,-0.1273842602968216,-0.2016663104295731,-0.1702322512865067,-0.1621448397636414,-0.1178624853491783,-0.1180150732398033,-0.1828669160604477,-0.07046724110841751,0.1027558222413063,0.03854487836360931,-0.1038850098848343,-0.08432263880968094,-0.0789819061756134,-0.1634266227483749,-0.2312997877597809,-0.2331919372081757,-0.2350535541772842,-0.2493667453527451,-0.1781670600175858,-0.1240272223949432,-0.1442609876394272,-0.1323282569646835,-0.0718405693769455,-0.05966368690133095,-0.123508408665657,-0.1781670600175858,-0.2447889596223831,-0.2559587359428406,-0.1960203796625137,-0.171605572104454,-0.1527756601572037,-0.1521347761154175,-0.1507309228181839,-0.07535020262002945,0.006653035059571266,0.03491317480802536,0.0714438334107399,0.1127353757619858,0.1179540380835533,0.1292764097452164,0.1780449897050858,0.234321117401123,0.224341556429863,0.1872615814208984,0.1979430466890335,0.2228766679763794,0.2361522316932678,0.2346873432397842,0.2605060040950775,0.2906888127326965,0.2830896973609924,0.2941679060459137,0.3029267191886902,0.2667317688465118,0.2799462974071503,0.3413495421409607,0.3557847738265991,0.3328653872013092,0.3252357542514801,0.3215735256671906,0.3036591708660126,0.3121433258056641,0.3320108652114868,0.3502914607524872,0.3704946935176849,0.3731192946434021,0.3212683498859406,0.2282479256391525,0.2104861587285995,0.1722159534692764,0.0874965637922287,0.0632648691534996,-0.02066103182733059,-0.1581469178199768,-0.2324289679527283,-0.2325510382652283,-0.1897335797548294,-0.1471297293901443,-0.1808526813983917,-0.2029786109924316,-0.1590929925441742,-0.1554002463817596,-0.2048402428627014,-0.2664876282215118,-0.2604754865169525,-0.2371288239955902,-0.1980651319026947,-0.1505478024482727,-0.1520432084798813,-0.1551255881786346,-0.158513143658638,-0.1524094343185425,-0.1355021893978119,-0.06140324100852013,0.06427197903394699,0.158543661236763,0.1731620281934738,0.1692861765623093,0.2004760950803757,0.2057252675294876,0.241859182715416,0.2237617075443268,0.1073336005210876,0.1101718172430992,0.1552476584911346,0.1949217170476913,0.1465498805046082,-0.01181066315621138,0.0120242927223444,0.08468886464834213,0.02969451062381268,-0.03118991665542126,-0.08481093496084213,-0.1644337326288223,-0.1553697288036346,-0.06711020320653915,-0.0551164299249649,-0.1299478113651276,-0.1044343411922455,0.04437391459941864,0.1471907645463943,0.1717276573181152,0.1407818794250488,0.1334574371576309,0.1507309228181839,0.156041145324707,0.1767021715641022,0.1858272105455399,0.1497848480939865,0.1363261789083481,0.1155735924839973,0.07065034657716751,0.06692709028720856,0.06210516765713692,0.05795465037226677,-0.009674367494881153,-0.09439375251531601,-0.1100802645087242,-0.1403851509094238,-0.2120425999164581,-0.221655935049057,-0.1032441183924675,-0.08462782949209213,-0.1922971308231354,-0.1695303171873093,-0.1007110849022865,-0.0952482670545578,-0.09369182586669922,-0.0870387926697731,-0.05410931631922722,-0.06405834853649139,0.001495406962931156,0.04223761707544327,-0.02426221594214439,0.008819849230349064,-0.03100680559873581,-0.08648945391178131,-0.08047731220722198,-0.06390576064586639,-0.07043672353029251,-0.1418195068836212,-0.1248817443847656,-0.0102237006649375,0.1008636727929115,0.09228797256946564,0.08310189843177795,0.1328165531158447,0.05655079707503319,0.01297036651521921,-0.001403851434588432,-0.1105380430817604,-0.09430219233036041,0.0791955292224884,0.1595507711172104,0.1368449926376343,0.1728263199329376,0.2280037850141525,0.2147892713546753,0.2019104659557343,0.2507705986499786,0.224250003695488,0.1769157946109772,0.1248817443847656,0.09765923023223877,0.09753715991973877,0.01028473768383265,0.01409955136477947,0.07013153284788132,0.09207434207201004,0.04916531965136528,0.0198065135627985,0.05133213475346565,-0.03750724717974663,-0.039613027125597,0.03567613661289215,0.0157170332968235,0.0199591051787138,0.0315866582095623,0.03433332219719887,-0.02865688130259514,-0.1028778925538063,-0.0709860548377037,-0.09445478767156601,-0.1500900238752365,-0.1297647058963776,-0.07678457349538803,0.00833155307918787,0.03259376809000969,-0.03912473097443581,-0.1177404075860977,-0.1189001128077507,0.00991851557046175,0.1731315106153488,0.2026734203100204,0.05984679609537125,-0.02896206639707088,0.04370250552892685,0.09985656291246414,0.06271553784608841,-0.01101718191057444,0.05914487317204475,0.1653187721967697,0.1212805584073067,0.07019257545471191,0.0237739197909832,0.02246162295341492,0.04309213533997536,0.0002136295661330223,0.0001831110566854477,0.01058992277830839,0.01901303231716156,0.01174962613731623,-0.003753776662051678,0.08594012260437012,0.1423078030347824,0.04123050719499588,-0.03683584183454514,-0.06021301820874214,-0.07632679492235184,-0.006927701644599438,0.05056916922330856,0.07480086386203766,0.06277657300233841,-0.00872829370200634,-0.03427228704094887,-0.07495345920324326,-0.1037324145436287,-0.09750663489103317,-0.0875270888209343,-0.03918576613068581,-0.05099643021821976,0.01144444104284048,0.1268349289894104,0.1771904677152634,0.2542191743850708,0.1782586127519608,0.1190527081489563,0.2144535630941391,0.1963866055011749,0.1628162413835526,0.1092257425189018,0.04181035980582237,0.05005035549402237,0.03830073028802872,0.09323404729366302,0.1468855887651443,0.1910153478384018,0.2286446690559387,0.114474929869175,0.02124088257551193,-0.02670369669795036,-0.06164738908410072,0.008392590098083019,0.03619495406746864,-0.01928769797086716,-0.09176915884017944,-0.1668141782283783,-0.1749931275844574,-0.1512497365474701,-0.1568651348352432,-0.1525620222091675,-0.1255226284265518,-0.1371501833200455,-0.1616565436124802,-0.1386455893516541,-0.1532334387302399,-0.2353282272815704,-0.2209234833717346,-0.1490218788385391,-0.01159703359007835,0.09949034452438354,0.01837214268743992,0.06915494054555893,0.1923886835575104,0.2056642323732376,0.2253181487321854,0.2504348754882812,0.3161717653274536,0.3804437518119812,0.3747978210449219,0.3644520342350006,0.3620410859584808,0.3469038903713226,0.3467818200588226,0.3511154651641846,0.3553880453109741,0.3661915957927704,0.3599963486194611,0.3454390168190002,0.3762932121753693,0.3119601905345917,0.1953184604644775,0.1400189250707626,0.1161839663982391,0.1302224844694138,0.03448591753840446,-0.03909420967102051,0.009704886004328728,0.05929746478796005,0.1042817458510399,0.1807611286640167,0.1667531430721283,0.03601184114813805,-0.004791405983269215,-0.001922666095197201,0.0200506616383791,0.04263435676693916,-0.04943998530507088,-0.1531724035739899,-0.1456648409366608,-0.1243629232048988,-0.141178622841835,-0.10849329829216,-0.112125001847744,-0.1862239390611649,-0.2168034911155701,-0.1862544566392899,-0.1656544655561447,-0.1874752044677734,-0.1894283890724182,-0.1405377388000488,-0.02615436352789402,0.06698812544345856,0.02636799216270447,0.002929776906967163,0.02978606522083282,-0.07889034599065781,-0.1821649819612503,-0.0711996853351593,0.08792382478713989,0.1869869083166122,0.2430799305438995,0.2222968190908432,0.1053804159164429,-0.01110873743891716,0.004119998775422573,0.02713095583021641,-0.03415021300315857,-0.1079744845628738,-0.09323404729366302,-0.04849391058087349,-0.1307412981987,-0.193670466542244,-0.1347087025642395,-0.1167638152837753,-0.1583605408668518,-0.108401745557785,-0.01519821770489216,-0.05465865135192871,-0.1081270799040794,-0.0279854740947485,0.008819849230349064,-0.09054841846227646,-0.125949889421463,-0.09408856183290482,-0.1266212910413742,-0.1631214320659637,-0.1825006902217865,-0.1531113684177399,-0.1151463389396667,-0.1533249914646149,-0.1465498805046082,-0.1324198096990585,-0.1272316724061966,-0.08270516246557236,-0.0631427988409996,-0.004486220888793468,0.05343791097402573,0.0872829407453537,0.1539963930845261,0.1807916462421417,0.1289407014846802,0.03601184114813805,-0.02945036254823208,-0.06607257574796677,-0.1162144839763641,-0.1833246797323227,-0.2227240800857544,-0.2462538480758667,-0.2023682296276093,-0.0949430838227272,-0.1210669279098511,-0.1730094254016876,-0.1349528431892395,-0.1660206913948059,-0.2226630449295044,-0.1749015748500824,-0.06701865047216415,0.01699881069362164,0.03573717549443245,0.09601122885942459,0.1397442519664764,0.1249122619628906,0.07000946253538132,-0.03057954646646976,-0.06250190734863281,-0.08453626930713654,-0.07473982870578766,0.02587969601154327,0.1005279719829559,0.08865626901388168,0.06161687150597572,0.06390576064586639,0.1401715129613876,0.2453993409872055,0.3106479048728943,0.3444624245166779,0.3418073058128357,0.3465987145900726,0.3413495421409607,0.330179750919342,0.34772789478302,0.3283791542053223,0.3039643466472626,0.3010040521621704,0.2878200709819794,0.2855006456375122,0.2361217141151428,0.2163457125425339,0.2395397871732712,0.1984313428401947,0.1169774457812309,0.00833155307918787,-0.06439405679702759,-0.1180150732398033,-0.1559495776891708,-0.1574144661426544,-0.2043824642896652,-0.2321848273277283,-0.2139042317867279,-0.1966307610273361,-0.1798455715179443,-0.1857661604881287,-0.204046756029129,-0.1810358017683029,-0.1463972926139832,-0.1815546154975891,-0.1511581838130951,-0.1092257425189018,-0.1492355167865753,-0.1361125558614731,-0.0636310949921608,-0.06949064880609512,-0.05468916893005371,0.01733451336622238,-0.02316354960203171,-0.06851405650377274,-0.113193154335022,-0.1771294325590134,-0.2219916433095932,-0.1999877989292145,-0.1536606997251511,-0.06613361090421677,-0.002746665850281715,-0.1137730032205582,-0.1734366863965988,-0.1716666221618652,-0.1105380430817604,-0.04086428508162498,-0.09463790059089661,-0.1066927090287209,-0.05023346841335297,0.04629657790064812,0.0712607204914093,-0.005981627851724625,-0.1019013002514839,-0.1248817443847656,-0.1099581867456436,-0.1674550622701645,-0.1921750605106354,-0.1999572813510895,-0.186498612165451,-0.2103030532598495,-0.2573626041412354,-0.2582170963287354,-0.234412670135498,-0.2195806801319122,-0.2130191922187805,-0.1468550711870193,-0.09994811564683914,-0.01132236700505018,0.1122165620326996,0.1576891392469406,0.188848540186882,0.2259285300970078,0.2144535630941391,0.1952269077301025,0.2058473527431488,0.191534161567688,0.20645771920681,0.1487777382135391,0.01345866266638041,-0.002685628831386566,-0.06924650073051453,-0.1750541776418686,-0.1945249736309052,-0.2021240890026093,-0.1868953555822372,-0.1087069287896156,-0.007873775437474251,0.1117282658815384,0.208777129650116,0.1896114945411682,0.1624805480241776,0.1850947588682175,0.2093569785356522,0.2176274955272675,0.2485122233629227,0.2981963455677032,0.3037812411785126,0.2473525255918503,0.191503643989563,0.236945703625679,0.3112888038158417,0.3122653961181641,0.2858363687992096,0.2621234655380249,0.2617572546005249,0.3058870136737823,0.3322855234146118,0.3573107123374939,0.3146763443946838,0.2377697080373764,0.2106082290410995,0.1209753751754761,0.1496017277240753,0.2708517611026764,0.2665791809558868,0.1502121090888977,0.09314249455928802,0.1236610040068626,0.1573534309864044,0.2283700108528137,0.2252876311540604,0.1641590595245361,0.06567583233118057,0.01806695759296417,0.09283730387687683,0.1697439551353455,0.1619006991386414,0.04620502516627312,0.0141911068931222,0.06418042629957199,0.06213568523526192,-0.02154606766998768,-0.1185338944196701,-0.1350749284029007,-0.1598559468984604,-0.1860408335924149,-0.1932737231254578,-0.2109134197235107,-0.2189092636108398,-0.2224494218826294,-0.2382580041885376,-0.2455519288778305,-0.2371288239955902,-0.2374339997768402,-0.2499465942382812,-0.2718893885612488,-0.2974944412708282,-0.3110446631908417,-0.304513692855835,-0.2885830402374268,-0.2661824524402618,-0.2634968161582947,-0.256996363401413,-0.2800988852977753,-0.2893764972686768,-0.2339854091405869,-0.2561418414115906,-0.1300393640995026,0.09625537693500519,0.1169164106249809,0.1390423327684402,0.1362651437520981,0.01913510635495186,-0.01495406962931156,-0.03582873195409775,-0.09912411868572235,-0.1400799602270126,-0.1776177287101746,-0.1790520995855331,-0.1979430466890335,-0.224280521273613,-0.2576372623443604,-0.2482070326805115,-0.221778005361557,-0.2601092457771301,-0.2256538569927216,-0.2169560790061951,-0.2423779964447021,-0.2199468910694122,-0.2528458535671234,-0.2851954698562622,-0.2711874842643738,-0.2887051105499268,-0.2759483754634857,-0.2181768268346786,-0.2313303053379059,-0.2599871754646301,-0.2354808151721954,-0.1874446868896484,-0.145908996462822,-0.1011078208684921,-0.1106601133942604,-0.2094180136919022,-0.2365489602088928,-0.1319009959697723,-0.0278939176350832,-0.0281380657106638,-0.0475478395819664,-0.07855464518070221,-0.07077242434024811,0.03289895504713058,0.03891110047698021,-0.005401776172220707,0.0160832554101944,0.08062990009784698,0.06228827685117722,-0.03277688100934029,-0.07660146057605743,0.003936887718737125,-0.003875850699841976,-0.1564989238977432,-0.08429212123155594,0.0315866582095623,0.0871303454041481,0.1495101749897003,0.1476485431194305,0.1316568553447723,0.1029389351606369,0.06622516363859177,0.1005890071392059,0.1429487019777298,0.09320352971553802,-0.0007324442267417908,-0.09259315580129623,-0.1033356711268425,-0.1168553754687309,-0.1684926897287369,-0.1799676567316055,-0.1091952249407768,-0.03057954646646976,-0.02221747487783432,0.01846369914710522,0.1081881150603294,0.1777397990226746,0.2142094224691391,0.20651875436306,0.1392559558153152,0.1687978804111481,0.2614215612411499,0.2646259963512421,0.2958159148693085,0.3363139629364014,0.3843196034431458,0.4219183921813965,0.3997619450092316,0.3960387110710144,0.3908505439758301,0.3913083374500275,0.3904538154602051,0.3763847649097443,0.3637806475162506,0.34760582447052,0.3261513113975525,0.317484050989151,0.3074434697628021,0.2678609490394592,0.2466811090707779,0.2811670303344727,0.3312173783779144,0.3324686288833618,0.365550696849823,0.4122745394706726,0.3990600407123566,0.3114719092845917,0.2257454097270966,0.2628559172153473,0.2591326534748077,0.2857142984867096,0.330545961856842,0.2135380059480667,0.1013214513659477,0.02722251042723656,-0.06402783095836639,-0.1061738952994347,-0.1172826290130615,-0.1532334387302399,-0.1576891392469406,-0.1514938771724701,-0.1771294325590134,-0.1882076412439346,-0.186376541852951,-0.1952574253082275,-0.2269051223993301,-0.2467116266489029,-0.2424390465021133,-0.2203741520643234,-0.1917783170938492,-0.2044740170240402,-0.2056947499513626,-0.2067934274673462,-0.2320322245359421,-0.2334665954113007,-0.2273934185504913,-0.2172612696886063,-0.2068544626235962,-0.1975768357515335,-0.2017578631639481,-0.2229987531900406,-0.2284310460090637,-0.1834467649459839,-0.1546678096055984,-0.2001403868198395,-0.1570787727832794,-0.09976501017808914,-0.1942808330059052,-0.0631122812628746,0.1272316724061966,0.1007110849022865,0.1934263110160828,0.2263863086700439,0.1684011369943619,0.1919919401407242,0.2400891184806824,0.2641987502574921,0.2584307491779327,0.2471388876438141,0.2033753544092178,0.209021270275116,0.1788079440593719,0.09595019370317459,0.08545182645320892,0.1264076679944992,0.1514328420162201,0.1532334387302399,0.1911069005727768,0.2001709043979645,0.08246101438999176,-0.03631702810525894,-0.03695791587233543,-0.07519760727882385,-0.1621448397636414,-0.06097598373889923,0.08133182674646378,-0.01037629321217537,-0.07232886552810669,0.04269539564847946,0.1012604162096977,0.0116580706089735,-0.02694784477353096,0.08142338693141937,0.01547288428992033,-0.1171300411224365,-0.0794702023267746,0.09121982753276825,0.2509231865406036,0.2130497097969055,0.1439558118581772,0.1567735821008682,0.1772820204496384,0.1481063216924667,0.06131168454885483,0.007110812701284885,0.06472975760698318,0.07519760727882385,0.1608630567789078,0.3052156269550323,0.2469252645969391,0.1809442490339279,0.1198767051100731,0.02249214239418507,-0.03262428566813469,-0.0238959938287735,-0.01470992155373096,-0.07687612622976303,-0.1008636727929115,-0.1227454468607903,-0.1384930014610291,-0.1228369995951653,-0.124637596309185,-0.1384624838829041,-0.1823786199092865,-0.1980956494808197,-0.1867732852697372,-0.2002929747104645,-0.2084414213895798,-0.2037110477685928,-0.2055421620607376,-0.2056031972169876,-0.1965086758136749,-0.1745048314332962,-0.1559190601110458,-0.14096499979496,-0.1469771414995193,-0.1754509061574936,-0.189092680811882,-0.219275489449501,-0.2359996289014816,-0.203863650560379,-0.1813714951276779,-0.1798760890960693,-0.1918698698282242,-0.1894589066505432,-0.1633350700139999,-0.1953184604644775,-0.2490310370922089,-0.2587969601154327,-0.2496719211339951,-0.2383495569229126,-0.2505569756031036,-0.2329172641038895,-0.2306588888168335,-0.1820123940706253,0.013702810741961,0.1489303261041641,0.128513440489769,0.05011139437556267,0.08969389647245407,0.2263252735137939,0.269844651222229,0.3039338290691376,0.3491317629814148,0.3630787134170532,0.4580523073673248,0.5028839707374573,0.4471266865730286,0.399975597858429,0.3712271451950073,0.3425397574901581,0.3220313191413879,0.3186742663383484,0.2876369655132294,0.2610858380794525,0.186590164899826,0.1580553650856018,0.2226935625076294,0.2155522257089615,0.2733848094940186,0.2755821347236633,0.1880855709314346,0.2047791928052902,0.143559068441391,0.02966399118304253,-0.07715079188346863,-0.1359599530696869,-0.1050141900777817,-0.1138950809836388,-0.1390118151903152,-0.1462447047233582,-0.1447798162698746,-0.1593676507472992,-0.1489913612604141,-0.1165501847863197,-0.1530503183603287,-0.156315803527832,-0.02337717823684216,0.1986754983663559,0.3539536595344543,0.3865779638290405,0.3621631562709808,0.3063448071479797,0.2617267370223999,0.2359996289014816,0.2095095664262772,0.1382488459348679,0.05841242894530296,0.06445509195327759,0.04696798697113991,-0.02197332680225372,-0.06292916834354401,-0.0715048685669899,-0.0633869469165802,-0.07663197815418243,-0.08429212123155594,-0.07016205042600632,-0.05761894583702087,-0.08185064047574997,-0.1270790696144104,-0.125766783952713,-0.04608295112848282,-0.003753776662051678,-0.008392590098083019,0.01904354989528656,-0.01361125521361828,-0.0790124237537384,-0.1015350818634033,-0.07855464518070221,-0.03009125031530857,-0.05389568954706192,-0.05227820575237274,0.03454695269465446,-0.02584917843341827,-0.1275978833436966,-0.1344340294599533,-0.1681874990463257,-0.1857661604881287,-0.1658375859260559,-0.128269299864769,-0.1140171512961388,-0.1331827789545059,-0.1148411482572556,-0.1007416024804115,-0.1128574460744858,-0.1383098810911179,-0.176458016037941,-0.1720938682556152,-0.1552476584911346,-0.1506698876619339,-0.1658375859260559,-0.2099368274211884,-0.2340464442968369,-0.2117374241352081,-0.1786858737468719,-0.1816156506538391,-0.1666005402803421,-0.1832941621541977,-0.2122867554426193,-0.1962035000324249,-0.1986449807882309,-0.158909872174263,-0.1173131540417671,-0.04412976652383804,0.04901272803544998,0.0950346365571022,0.04089480265974998,-0.01797540299594402,0.08539079129695892,0.09317301213741302,0.1815240979194641,0.3712576627731323,0.3965880274772644,0.2575457096099854,0.05883968621492386,-0.02649006620049477,-0.1227759644389153,-0.208807647228241,-0.143559068441391,-0.0102237006649375,-0.03274635970592499,-0.06900235265493393,-0.02203436382114887,0.004882961511611938,0.05154576152563095,0.1008331552147865,0.1790520995855331,0.1825312077999115,0.1243629232048988,0.1807611286640167,0.2060609757900238,0.110812708735466,0.05307168886065483,0.04293954372406006,0.005005035549402237,-0.03381450846791267,0.004791405983269215,0.05816828086972237,0.03640858083963394,0.006378368474543095,-0.0008545182645320892,-0.02771080657839775,-0.05352946743369102,0.0039674062281847,0.0317697674036026,-0.01001007109880447,-0.009613330475986004,-0.04821924492716789,0.01327555160969496,0.161046177148819,0.1416364014148712,0.0715964213013649,0.07287820428609848,0.04104739427566528,-0.02084414288401604,-0.02465895563364029,-0.01504562515765429,-0.03125095367431641,0.01287881098687649,0.0711386427283287,0.001739555038511753,-0.04699850454926491,-0.003448591567575932,-0.006500442512333393,-0.03048799186944962,-0.07623523473739624,-0.09671315550804138,-0.09311196953058243,-0.0874660462141037,-0.0316476933658123,-0.03222754597663879,0.02703939937055111,0.09900204837322235,0.1041596755385399,0.07998901605606079,0.07376323640346527,0.1395916640758514,0.1296426355838776,0.1632129848003387,0.2003540098667145,0.1935178637504578,0.2629779875278473,0.2327341586351395,0.2135074883699417,0.286935031414032,0.2106997966766357,0.07403790205717087,-0.0313119925558567,-0.07727286964654922,-0.07889034599065781,-0.09854426980018616,-0.08539079129695892,-0.08801538497209549,-0.12466811388731,-0.07858516275882721,0.01498458813875914,0.02093569748103619,-0.04889065399765968,-0.0552385039627552,0.03344828635454178,0.04382457956671715,0.007751701399683952,-0.01950132846832275,-0.05868709459900856,-0.05713064968585968,-0.05371257662773132,-0.07061982899904251,-0.1042207106947899,-0.1374553740024567,-0.1263161152601242,-0.08096560835838318,-0.06033509224653244,-0.09686575084924698,-0.1057161167263985,-0.1101718172430992,-0.1032136008143425,-0.08014160394668579,-0.1221350729465485,-0.1018402650952339,-0.01559495832771063,0.02594073303043842,-0.001037629321217537,-0.06179998070001602,-0.06237983331084251,-0.04474013671278954,-0.08667256683111191,-0.128299817442894,-0.1277199685573578,-0.1052583381533623,-0.06866664439439774,-0.05697805806994438,-0.08310189843177795,-0.1322367042303085,-0.1312295943498611,-0.08200323581695557,-0.09942930191755295,-0.13068026304245,-0.1240577399730682,-0.07412946224212646,-0.04089480265974998,-0.05606250092387199,-0.08597064018249512,-0.1241493001580238,-0.09903256595134735,-0.03695791587233543,0.08310189843177795,0.1854609847068787,0.1952574253082275,0.2424085140228271,0.3162022829055786,0.3363749980926514,0.2889492511749268,0.2590105831623077,0.3075655400753021,0.3070161938667297,0.269783616065979,0.2810754776000977,0.2783898413181305,0.2209845334291458,0.1767937242984772,0.2175359427928925,0.2303842306137085,0.1850032061338425,0.0870387926697731,-0.03238013759255409,-0.0559099093079567,-0.03311258181929588,-0.05218665301799774,-0.0238959938287735,-0.01535081025213003,-0.09033478796482086,-0.009949034079909325,0.07586901634931564,0.09002960473299026,0.1549729853868484,0.1603137254714966,0.1256752163171768,0.1287881135940552,0.1772515028715134,0.1351359635591507,0.06530961394309998,0.04300057888031006,-0.02264473401010036,-0.06106753647327423,-0.05987731739878654,-0.07892086356878281,-0.1061128601431847,-0.14090396463871,-0.1494796574115753,-0.1114230751991272,-0.08520767837762833,-0.05703909322619438,-0.08417005091905594,-0.1555833667516708,-0.1502121090888977,-0.1239661872386932,-0.1153904870152473,-0.08444471657276154,-0.07394634932279587,-0.1188695952296257,-0.1832331269979477,-0.2124088257551193,-0.2129276394844055,-0.2220526784658432,-0.2167424559593201,-0.2210455685853958,-0.2450331151485443,-0.2248298525810242,-0.2073732763528824,-0.2358470410108566,-0.2465895563364029,-0.2256538569927216,-0.1999267488718033,-0.193639948964119,-0.1857356429100037,-0.171300396323204,-0.1625110656023026,-0.1368449926376343,-0.1295815855264664,-0.07992797344923019,-0.03524887934327126,-0.08996856957674026,-0.1351664811372757,-0.08072146028280258,0.005249183624982834,-0.02563554793596268,-0.03353984281420708,0.02264473401010036,0.0472426526248455,0.06097598373889923,0.03109836205840111,0.03921628370881081,0.1163975968956947,0.1119113713502884,0.09457685798406601,0.1572618782520294,0.1304666250944138,0.1521652936935425,0.2708822786808014,0.2137211263179779,0.08563493937253952,0.1030304878950119,0.1919919401407242,0.1692251414060593,0.031525619328022,-0.0115359965711832,0.01504562515765429,-0.002410962246358395,-0.007385479286313057,-0.005462813191115856,-0.01882992126047611,-0.01028473768383265,-0.01055940426886082,-0.0473036915063858,-0.09149449318647385,-0.06234931573271751,0.004455702379345894,-0.07989745587110519,-0.1493270695209503,-0.1037018969655037,-0.04992828145623207,-0.03018280677497387,-0.08883938193321228,-0.1333658844232559,-0.1652577221393585,-0.1650746166706085,-0.130832850933075,-0.1601916551589966,-0.1909848302602768,-0.1841181665658951,-0.171605572104454,-0.1812799423933029,-0.1839655786752701,-0.161320835351944,-0.1300088465213776,-0.1325418800115585,-0.110934779047966,-0.07678457349538803,-0.1148716732859612,-0.1187780424952507,-0.03408917412161827,0.004638813436031342,0.02459791861474514,0.1822565346956253,0.2950834631919861,0.3216040432453156,0.335215300321579,0.3415326476097107,0.3405255377292633,0.3163243532180786,0.2793359160423279,0.2443311810493469,0.2228156328201294,0.193609431385994,0.1781670600175858,0.1498458832502365,0.110782191157341,0.1102328598499298,0.1691640913486481,0.1954405307769775,0.1463362574577332,0.1117587834596634,0.1647694259881973,0.176183357834816,0.1485335826873779,0.1544541716575623,0.1052278205752373,0.1238135918974876,0.1156346350908279,0.0277413260191679,-0.002044740132987499,0.03570665791630745,0.08401745557785034,0.04431287571787834,0.01425214391201735,-0.04068117216229439,-0.0950956791639328,-0.1006805598735809,-0.1523178815841675,-0.1669362485408783,-0.1593066155910492,-0.1850642412900925,-0.2006897181272507,-0.208807647228241,-0.2339243739843369,-0.2715842127799988,-0.2475356310606003,-0.2062135636806488,-0.2127140164375305,-0.1972106099128723,-0.2156743109226227,-0.2375560849905014,-0.2075868993997574,-0.2109744548797607,-0.2461622953414917,-0.2372814118862152,-0.2081057131290436,-0.2146061658859253,-0.2251960784196854,-0.2499465942382812,-0.2706076204776764,-0.257148951292038,-0.2421338558197021,-0.2386547476053238,-0.2224189043045044,-0.2102725356817245,-0.189184233546257,-0.1879635006189346,-0.1425824761390686,-0.079317606985569,-0.08331552892923355,0.0158391073346138,0.1620227694511414,0.2189092636108398,0.2154911905527115,0.257148951292038,0.2607806622982025,0.2471999228000641,0.2362437844276428,0.1661427617073059,0.1464583277702332,0.1861629039049149,0.2352671921253204,0.219336524605751,0.2562028765678406,0.3270973861217499,0.317728191614151,0.2882778346538544,0.2271492630243301,0.1363566964864731,0.07693716138601303,0.01043733023107052,-0.01437421794980764,-0.02536088228225708,-0.09820856153964996,-0.08084353059530258,-0.05221717059612274,-0.06735435128211975,-0.0717490166425705,-0.08658101409673691,-0.1116061881184578,-0.1149937435984612,-0.0951261967420578,-0.06982634961605072,-0.07974486798048019,-0.1219519674777985,-0.06772056967020035,-0.05902279913425446,-0.03891110047698021,0.01605273596942425,-0.0400402843952179,-0.02935880608856678,0.03418073058128357,0.0313119925558567,-0.007415997795760632,-0.0278939176350832,-0.1154515221714973,-0.05835139006376266,0.1775872111320496,0.2625812590122223,0.2654500007629395,0.2313913404941559,0.2237922251224518,0.2804345786571503,0.2929471731185913,0.2831507325172424,0.2728659808635712,0.1898861676454544,0.1443525552749634,0.128269299864769,0.04025391489267349,-0.004547257907688618,0.02157658711075783,0.0280159916728735,-0.05044709518551826,-0.06436353921890259,-0.01504562515765429,0.01440473645925522,0.01602221839129925,-0.08417005091905594,-0.1255531460046768,-0.09366130828857422,-0.1099581867456436,-0.1207007020711899,-0.07315286993980408,0.009247108362615108,-0.01556443981826305,-0.07989745587110519,-0.07650990039110184,-0.05267494916915894,-0.05899227783083916,-0.08352915942668915,-0.07013153284788132,-0.06140324100852013,-0.0557878352701664,-0.05929746478796005,-0.05844294652342796,-0.0796227902173996,-0.1001007109880447,-0.07559435069561005,-0.0715659037232399,-0.09445478767156601,-0.1262245625257492,-0.1548509150743484,-0.189184233546257,-0.1968443840742111,-0.2009949088096619,-0.2186346054077148,-0.2248603850603104,-0.2078310549259186,-0.1771294325590134,-0.1769463121891022,-0.1840266138315201,-0.1807611286640167,-0.1528977304697037,-0.1421552151441574,-0.1372722536325455,-0.1381267756223679,-0.1658681035041809,-0.1453901827335358,-0.1007110849022865,-0.05703909322619438,-0.05658131837844849,-0.06018250063061714,-0.06198309361934662,-0.06244087219238281,-0.06729331612586975,-0.1450849920511246,-0.1566515117883682,-0.1606189161539078,-0.1136509329080582,-0.01272621843963861,-0.02960295416414738,-0.0121463667601347,-0.001525925472378731,-0.0632343515753746,-0.1001312285661697,-0.01409955136477947,0.1684621721506119,0.2008728235960007,0.0395519882440567,-0.04312265291810036,-0.02795495465397835,-0.01751762442290783,0.01681569963693619,-0.02719199284911156,-0.05124057829380035,0.0202032532542944,0.06875820457935333,0.004119998775422573,0.04031495004892349,0.1726126968860626,0.08481093496084213,0.09009063988924026,0.2101199328899384,0.2604144513607025,0.3086947202682495,0.281838446855545,0.221655935049057,0.1426740288734436,0.08999908715486526,0.08005005121231079,0.05786309391260147,0.05087435618042946,0.1044953763484955,0.07507553696632385,-0.007415997795760632,-0.04205450788140297,-0.07892086356878281,-0.06802576035261154,-0.03650013729929924,-0.0715048685669899,-0.09744559973478317,-0.01965392008423805,-0.04187139496207237,-0.06128116697072983,-0.01901303231716156,-0.07489242404699326,-0.1126132979989052,-0.0473036915063858,0.02859584428369999,-0.01779229193925858,-0.07220679521560669,-0.08978545665740967,-0.1086458936333656,-0.1264687031507492,-0.08062990009784698,-0.08676411956548691,-0.1945554912090302,-0.1968443840742111,-0.1329386234283447,-0.08920560032129288,-0.1448408514261246,-0.1858272105455399,-0.1394390761852264,-0.09787286072969437,-0.081545457243]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>AR15</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>9mm Baretta</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>357 Desert Eagle</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>generic</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>note</key><value>luger</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_0</value></param>
<param><key>note</key><value>308 sig sauer</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0_1</value></param>
<param><key>note</key><value>pistol 38</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>pistol_38</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[0.03668325021862984,0.04474013671278954,0.05044709518551826,0.03793450817465782,0.0318613238632679,0.02853480726480484,0.02420117892324924,-0.002899258397519588,-0.01718192175030708,-0.01928769797086716,-0.02264473401010036,-0.009949034079909325,-0.02999969571828842,-0.02465895563364029,-0.01815851405262947,-0.03286843374371529,-0.02237006835639477,-0.01144444104284048,-0.0001831110566854477,-0.001892147585749626,0.007660145871341228,0.01101718191057444,-0.004119998775422573,0.007202368229627609,0.02554399333894253,0.0238044373691082,0.02066103182733059,0.02026429027318954,0.006225775927305222,-0.002746665850281715,-0.004303109832108021,0.003112887963652611,0.007477034814655781,0.002441480755805969,0.002563554793596268,-0.008514664135873318,-0.02563554793596268,-0.01532029174268246,-0.01049836724996567,-0.004455702379345894,-0.006775109097361565,-0.007110812701284885,-0.004242072813212872,-0.006591998040676117,-0.003021332435309887,0.01174962613731623,-0.006500442512333393,-0.004058961756527424,-0.006561479531228542,-0.006225775927305222,-0.01116977445781231,0.001342814415693283,0.009796441532671452,-0.004638813436031342,-0.01263466291129589,-0.02548295632004738,-0.03006073273718357,-0.01913510635495186,-0.01074251532554626,-0.01019318215548992,0.002746665850281715,0.005981627851724625,0.01501510664820671,0.02249214239418507,0.01870784722268581,0.03918576613068581,0.03732413798570633,0.01657155156135559,-0.003357036039233208,-0.001434369944036007,0.009979552589356899,0.0008545182645320892,-0.002258369699120522,-0.01269569993019104,-0.0275276955217123,-0.009308145381510258,-0.01867732778191566,-0.03024384379386902,-0.01614429242908955,-0.006134220398962498,-0.006653035059571266,0.004486220888793468,0.007690664380788803,9.155552834272385e-05,0.009765923023223877,0.01361125521361828,0.01934873498976231,0.004882961511611938,-0.004425183869898319,0.002655110321938992,0.01355021819472313,0.01849421672523022,0.01281777396798134,-0.003143406473100185,-0.03805658221244812,-0.03262428566813469,-0.01251258887350559,-0.01577807031571865,-0.01513718068599701,-0.01089510787278414,-0.0003051850944757462,0.003845332190394402,0.00158696249127388,0.01037629321217537,0.01641895808279514,0.001373332925140858,0.00079348124563694,0.008636738173663616,-0.005584887228906155,-0.01751762442290783,-0.03070162050426006,-0.02758873254060745,-0.02822962217032909,-0.01525925472378731,-0.004425183869898319,-0.01431318093091249,-0.009857478551566601,-0.02111880853772163,-0.01028473768383265,0.005829035304486752,-0.005401776172220707,0.006439405493438244,0.01196325570344925,0.01782280951738358,0.02154606766998768,0.03372295200824738,0.03491317480802536,0.04388561844825745,0.0281075481325388,0.03299050778150558,0.02655110321938992,0.02191228978335857,0.02130191959440708,-0.006836146116256714,0.006469924002885818,0.0079348124563694,-0.003204443491995335,-0.005066072568297386,-0.01840266212821007,-0.03634754568338394,-0.0238044373691082,-0.0157475508749485,0.008453627116978168,0.01910458691418171,0.01355021819472313,0.02539139986038208,0.02529984526336193,0.01101718191057444,0.01007110811769962,0.005127109587192535,-0.007477034814655781,-0.01785332895815372,-0.02056947536766529,-0.009094515815377235,-0.01019318215548992,-0.02578814141452312,-0.02117984555661678,0.004425183869898319,-0.008758812211453915,-0.0139469588175416,-0.02316354960203171,-0.01821955107152462,0.01351969968527555,0.01748710684478283,0.009887997061014175,0.01138340402394533,0.01367229223251343,0.01901303231716156,0.01110873743891716,0.009887997061014175,-0.001037629321217537,-0.0135807367041707,-0.001129184849560261,-0.001556443981826305,-0.005523850210011005,-0.01455732900649309,-0.02069154940545559,-0.01739555038511753,-0.02301095612347126,-0.03424176946282387,-0.01696829125285149,0.002502517774701118,-0.005340739153325558,-0.007477034814655781,0.0001831110566854477,-0.001373332925140858,-0.004272591322660446,-0.005310220643877983,0.001647999510169029,0.002990813925862312,-0.01004058960825205,-0.005829035304486752,-0.003479110077023506,-0.0003357036039233208,0.009582811966538429,0.0197149571031332,0.02560503035783768,0.02038636431097984,0.02044740132987499,0.0320139154791832,0.04251228272914886,0.02041688375174999,-0.0005493331700563431,0.006775109097361565,0.0315866582095623,0.04474013671278954,0.03839228674769402,0.01364177372306585,-0.005523850210011005,0.01049836724996567,0.01312295906245708,0.01092562638223171,0.0115359965711832,-0.00872829370200634,-0.02087466046214104,-0.0198370311409235,-0.008392590098083019,-0.0119022186845541,-0.0121463667601347,-0.005584887228906155,0.0007629627361893654,-0.008819849230349064,-0.01528977323323488,-0.006622516550123692,-0.01065095979720354,-0.01052888575941324,-0.01123081147670746,-0.02896206639707088,-0.02047792077064514,-0.01391644030809402,-0.01019318215548992,0.009430219419300556,0.002563554793596268,-0.01327555160969496,-0.02313303016126156,-0.02078310586512089,-0.01528977323323488,-0.0002441480755805969,0.01144444104284048,0.02047792077064514,0.0120242927223444,-0.007843256928026676,-0.002197332680225372,-0.006408886983990669,-0.0009765923023223877,-0.005340739153325558,-0.01110873743891716,-0.001770073547959328,-0.0004272591322660446,-0.0001220740377902985,-0.007507553324103355,-0.002349925227463245,-0.005096591077744961,-0.004730368964374065,-0.006164738908410072,-0.007110812701284885,-0.005645924247801304,-0.01919614337384701,0.01541184727102518,0.03036591783165932,0.01617481000721455,0.009887997061014175,0.007293923757970333,0.013702810741961,0.02294991910457611,0.01702932827174664,-0.002716147340834141,0.005188146606087685,0.008636738173663616,0.02237006835639477,0.02972502820193768,0.004730368964374065,-0.01278725545853376,-0.02105777151882648,-0.006408886983990669,-0.02105777151882648,-0.0471816174685955,-0.0240485854446888,-0.008758812211453915,-0.02063051238656044,-0.0276497695595026,-0.0135807367041707,0.007812738418579102,-0.009430219419300556,-0.01199377421289682,-0.001312295906245708,-0.01940977200865746,-0.01580858789384365,-0.01458784751594067,0.006927701644599438,0.02560503035783768,0.0398266538977623,0.04531998559832573,0.04272591322660446,0.05169835686683655,0.03555406257510185,0.009186071343719959,0.006591998040676117,-0.003082369454205036,-0.005767998285591602,-0.01135288551449776,-0.02627643756568432,-0.02478102967143059,-0.03250221163034439,-0.0320749543607235,-0.031525619328022,-0.06204412877559662,-0.05850398167967796,-0.04330576583743095,-0.02627643756568432,-0.03454695269465446,-0.03357036039233208,-0.0234076976776123,-0.0162053294479847,-0.0140690328553319,-0.01647999510169029,0.006622516550123692,0.009552293457090855,0.001373332925140858,0.004821924492716789,0.001281777396798134,0.01727347634732723,0.0195928830653429,0.0313730277121067,0.02221747487783432,0.002441480755805969,0.00277718435972929,-0.0007019257172942162,0.004882961511611938,0.02841273322701454,0.03781243413686752,0.03482161834836006,0.04824976250529289,0.05355998501181602,0.04095584154129028,0.04947050288319588,0.05252235382795334,0.03900265693664551,0.01089510787278414,-0.02652058564126492,-0.05355998501181602,-0.07705923914909363,-0.0874355286359787,-0.07773064076900482,-0.07275612652301788,-0.08551286160945892,-0.08273568004369736,-0.07467879354953766,-0.07040619850158691,-0.04635761678218842,-0.0281380657106638,-0.01858577318489552,-0.01251258887350559,-0.006897183135151863,0.02191228978335857,0.0394909530878067,0.03701895102858543,0.04675435647368431,0.02502517774701118,0.001098666340112686,-0.008911404758691788,-0.009674367494881153,0.003112887963652611,-0.002990813925862312,-0.01489303261041641,-0.001007110811769962,0.00238044373691082,0.002166814170777798,0.01715140230953693,0.009155552834272385,0.02694784477353096,0.0200506616383791,0.01541184727102518,0.00079348124563694,0.0006103701889514923,0.006561479531228542,0.001770073547959328,0.009063997305929661,-0.01831110566854477,-0.01876888424158096,-0.008087405003607273,0.002136295661330223,0.002502517774701118,-0.005218665115535259,-0.01712088473141193,0.003418073058128357,0.01492355111986399,0.01806695759296417,0.02838221378624439,0.01235999632626772,0.004272591322660446,0.01141392253339291,0.01220740377902985,0.005920590832829475,-0.0079348124563694,-0.01669362559914589,-0.02444532699882984,-0.03299050778150558,-0.03238013759255409,-0.03881954401731491,-0.0393078401684761,-0.02926725149154663,-0.01654103212058544,-0.01776177249848843,0.004669331945478916,0.01422162540256977,0.02282784506678581,0.05139316990971565,0.04690694808959961,0.05465865135192871,0.04367198795080185,0.0319528803229332,0.03271584212779999,0.03320413827896118,0.02941984310746193,0.03830073028802872,0.005676442757248878,-0.01513718068599701,-0.01681569963693619,-0.02264473401010036,-0.03045747242867947,-0.05044709518551826,-0.06857509166002274,-0.06561479717493057,-0.09326456487178802,-0.1052888557314873,-0.08047731220722198,-0.05243080109357834,-0.05429242923855782,-0.0319528803229332,-0.02078310586512089,-0.02511673420667648,0.009399700909852982,0.04312265291810036,0.07254249602556229,0.06848353892564774,0.0477004311978817,0.04086428508162498,0.03079317696392536,0.01013214513659477,0.001403851434588432,0.01254310738295317,-0.002929776906967163,-0.007415997795760632,-0.008545182645320892,-0.01516769919544458,0.01626636646687984,0.02838221378624439,0.01812799461185932,0.02661214023828506,0.04037598893046379,0.04086428508162498,0.04940946772694588,0.05844294652342796,0.04193243384361267,0.02853480726480484,0.01263466291129589,0.0001831110566854477,-0.007263405248522758,-0.02706991881132126,-0.03308206424117088,-0.03833124786615372,-0.05377361550927162,-0.06213568523526192,-0.07242042571306229,-0.06781212985515594,-0.04925687611103058,-0.04052858054637909,-0.0241401419043541,-0.007507553324103355,0.006012146361172199,0.007477034814655781,0.01989806815981865,0.0156254768371582,0.03903317451477051,0.05664235353469849,0.05151524394750595,0.05072176456451416,0.04709006100893021,0.04709006100893021,0.05490279942750931,0.03375347331166267,0.01699881069362164,0.0201727356761694,0.02627643756568432,0.01477095857262611,0.02539139986038208,0.01455732900649309,-0.0005188146606087685,0.009552293457090855,0.02548295632004738,0.02285836450755596,0.03808709979057312,0.04226813465356827,0.02822962217032909,0.02249214239418507,0.003265480510890484,-0.009887997061014175,-0.004150517284870148,-0.00079348124563694,-0.003082369454205036,-0.01269569993019104,-0.02029480971395969,-0.01062044128775597,-0.008239997550845146,-0.03277688100934029,-0.05090487375855446,-0.03878902643918991,-0.04022339731454849,-0.0479750968515873,-0.05069124326109886,-0.06466872245073318,-0.05423139035701752,-0.04467909783124924,-0.04257332161068916,-0.04272591322660446,-0.039704579859972,-0.04046754539012909,-0.03689687699079514,-0.01870784722268581,-0.01669362559914589,-0.004119998775422573,0.01556443981826305,0.02371288277208805,0.03341776877641678,0.01776177249848843,0.01107821892946959,0.03018280677497387,0.04959257692098618,0.05365154147148132,0.03546250984072685,0.03860591351985931,0.0392773225903511,0.04083376750349998,0.0318918414413929,0.04150517284870148,0.05307168886065483,0.03353984281420708,0.01431318093091249,0.01269569993019104,-0.001098666340112686,0.01248207036405802,0.007507553324103355,-0.01290932949632406,-0.03222754597663879,-0.02609332650899887,-0.01779229193925858,-0.02011169865727425,-0.03787346929311752,-0.04303110018372536,-0.03485213965177536,-0.04126102477312088,-0.02819910272955894,-0.0009155552834272385,0.008117923513054848,-0.002227851189672947,-0.003540147095918655,-0.0008545182645320892,-0.0009155552834272385,-0.002685628831386566,-0.009216589853167534,-0.01855525374412537,-0.01663258858025074,-0.0004577776417136192,0.004150517284870148,-0.01998962461948395,-0.03704947233200073,-0.04275643080472946,-0.008148442022502422,0.009796441532671452,0.02621540054678917,0.002960295416414738,-0.004577776417136192,-0.0009460737928748131,-0.00674459058791399,0.01318399608135223,0.01470992155373096,-0.005493331700563431,0.008850367739796638,0.005401776172220707,0.0157170332968235,0.03408917412161827,0.04974517226219177,0.03863643482327461,0.0121463667601347,-0.0006103701889514923,-0.01431318093091249,-0.01626636646687984,-0.02063051238656044,-0.02514725178480148,-0.02038636431097984,-0.04141361638903618,-0.05603198334574699,-0.0715964213013649,-0.06256294250488281,-0.02410962246358395,-0.005340739153325558,-0.0116580706089735,-0.01440473645925522,-0.01107821892946959,-0.01660206913948059,0.01538132876157761,0.04943998530507088,0.04107791557908058,0.0277413260191679,0.03390606492757797,0.04284798726439476,0.008911404758691788,-0.0140690328553319,-0.0235297717154026,-0.01580858789384365,0.006500442512333393,0.001434369944036007,-0.01522873621433973,-0.02606280706822872,-0.02975554764270782,-0.01333658862859011,-0.02194280922412872,-0.02597125247120857,-0.02908414043486118,-0.006683553569018841,-0.008148442022502422,-0.02139347605407238,0.005005035549402237,0.01443525496870279,0.02169866114854813,0.01138340402394533,0.007415997795760632,0.001037629321217537,0.02502517774701118,0.0240485854446888,-0.007568590342998505,0.002868739888072014,-0.01931821741163731,-0.02371288277208805,-0.04086428508162498,-0.05673390999436378,-0.0710165724158287,-0.07428205013275146,-0.04065065458416939,-0.03555406257510185,-0.03546250984072685,-0.04525895044207573,-0.01144444104284048,-0.006195257417857647,0.004608294926583767,0.009338663890957832,0.0140690328553319,0.02230903133749962,0.0317697674036026,0.03769036009907722,0.04242072999477386,0.05505539104342461,0.06457716971635818,0.05847346410155296,0.03415021300315857,0.01928769797086716,-0.006225775927305222,-0.01434369944036007,-0.01873836480081081,-0.002960295416414738,-0.0004882961511611938,-0.005462813191115856,-0.008850367739796638,0.006256294436752796,0.001800592057406902,-0.003418073058128357,-0.008209479041397572,-0.02526932582259178,-0.03601184114813805,-0.03668325021862984,-0.01477095857262611,-0.02014221623539925,-0.004608294926583767,0.01785332895815372,-0.001251258887350559,-0.02395703084766865,-0.02011169865727425,-0.005676442757248878,0.002746665850281715,-0.007782219909131527,-0.01742606982588768,-0.00357066560536623,-0.006317331455647945,0.02102725394070148,0.0399792492389679,0.04431287571787834,0.05890072509646416,0.04934842884540558,0.05627613142132759,0.05945005640387535,0.04925687611103058,0.04074221104383469,0.01525925472378731,-0.009857478551566601,-0.005432294681668282,0.01886043883860111,0.00872829370200634,-0.0202032532542944,-0.03079317696392536,-0.05194250494241714,-0.08093509078025818,-0.07358012348413467,-0.07510605454444885,-0.06692709028720856,-0.07629627734422684,-0.06952116638422012,-0.05502487346529961,-0.03027436137199402,-0.01028473768383265,-0.00634784996509552,0.003112887963652611,0.001892147585749626,-0.01907406933605671,-0.007965330965816975,0.02966399118304253,0.04858546704053879,0.02023377269506454,0.00476088747382164,0.02551347389817238,0.04809717088937759,0.04055909812450409,0.03881954401731491,0.02694784477353096,0.05639820545911789,0.04306161776185036,0.01120029296725988,0.009277626872062683,0.009735404513776302,0.02044740132987499,0.01901303231716156,0.01443525496870279,0.01348918117582798,0.009857478551566601,-0.003845332190394402,-0.03045747242867947,-0.04126102477312088,-0.03265480697154999,-0.003387554548680782,0.02865688130259514,0.04647969081997871,0.0115359965711832,0.006042664870619774,0.01086458936333656,0.008087405003607273,-0.01095614489167929,-0.0235297717154026,-0.02484206669032574,-0.0395825058221817,-0.01031525619328022,0.01058992277830839,-0.009826960042119026,-0.02862636186182499,-0.01513718068599701,0.01046784874051809,0.002166814170777798,0.0001831110566854477,-0.01004058960825205,0.008667256683111191,-0.007660145871341228,-0.01232947781682014,0.007110812701284885,-0.01196325570344925,-0.03076265752315521,-0.03793450817465782,-0.05459761247038841,-0.03387554734945297,-0.02636799216270447,-0.03387554734945297,-0.03811761736869812,-0.03518784046173096,0.006591998040676117,0.01580858789384365,-0.01135288551449776,-0.001709036529064178,-0.007324442267417908,0.002838221378624439,-0.008148442022502422,0.02917569503188133,0.04449598863720894,0.02908414043486118,0.0395519882440567,0.03118991665542126,0.02298043854534626,0.0121463667601347,0.03006073273718357,0.02264473401010036,-0.002746665850281715,-0.002502517774701118,-0.008026367984712124,0.007110812701284885,0.02758873254060745,0.02142399363219738,0.02075258642435074,0.02838221378624439,0.03024384379386902,0.03674428537487984,0.04443494975566864,0.05795465037226677,0.05685598403215408,0.04071169346570969,0.0313730277121067,0.004577776417136192,0.0005188146606087685,0.002014221623539925,0.005767998285591602,-0.01297036651521921,-0.02520828880369663,0.002685628831386566,0.009674367494881153,0.0009765923023223877,0.003387554548680782,0.008026367984712124,0.01232947781682014,0.01120029296725988,0.0238959938287735,0.02157658711075783,0.02966399118304253,0.009033478796482086,-0.005249183624982834,-0.01892147585749626,-0.02084414288401604,-0.04110843315720558,-0.05777153745293617,-0.01876888424158096,-0.02459791861474514,-0.01367229223251343,-0.02105777151882648,-0.02572710439562798,-0.03366191685199738,-0.04663228243589401,-0.01882992126047611,-0.01702932827174664,-0.002227851189672947,0.0158696249127388,-0.002502517774701118,-0.009613330475986004,-0.03103732503950596,-0.02633747458457947,-0.04278695210814476,-0.04635761678218842,-0.05044709518551826,-0.0394909530878067,-0.03329569473862648,-0.03753776848316193,-0.04596087709069252,-0.02975554764270782,-0.009704886004328728,-0.03753776848316193,-0.03814813867211342,-0.008453627116978168,0.03811761736869812,0.05172887444496155,0.05490279942750931,0.04092532023787498,0.02203436382114887,0.03091525100171566,0.04629657790064812,0.02822962217032909,0.003021332435309887,0.007263405248522758,0.007782219909131527,-0.0039674062281847,-0.02716147340834141,-0.01284829247742891,0.0039674062281847,-0.01043733023107052,-0.0278939176350832,-0.02700888179242611,0.003936887718737125,0.04162724688649178,0.0320444367825985,0.0274971779435873,0.03671376779675484,0.01293984800577164,0.0238959938287735,0.02194280922412872,-0.009857478551566601,-0.03482161834836006,-0.03326517716050148,-0.0238959938287735,-0.01388592179864645,-0.03823969140648842,-0.04263435676693916,-0.02838221378624439,-0.008453627116978168,0.01776177249848843,0.02951139956712723,0.02429273352026939,0.02261421643197536,0.0116580706089735,0.008636738173663616,-0.0004577776417136192,-0.001373332925140858,0.01309244055300951,0.06097598373889923,0.05600146576762199,0.02713095583021641,-0.0116580706089735,-0.003509628586471081,-0.00991851557046175,0.001373332925140858,0.006103701889514923,-0.02471999265253544,-0.002746665850281715,0.007690664380788803,0.007477034814655781,0.02612384408712387,0.0319223627448082,0.007843256928026676,0.004943998530507088,-0.01489303261041641,-0.02862636186182499,-0.02264473401010036,-0.02972502820193768,-0.04013184085488319,-0.03106784261763096,-0.03421124815940857,-0.05621509626507759,-0.05841242894530296,-0.05423139035701752,-0.03756828606128693,-0.05191198363900185,-0.02160710468888283,0.001129184849560261,0.0316476933658123,0.05771050229668617,0.05987731739878654,0.06274605542421341,0.0472731702029705,0.04364147037267685,0.06292916834354401,0.06851405650377274,0.06082338839769363,0.05816828086972237,0.05038606002926826,0.05136265233159065,0.02822962217032909,0.03353984281420708,0.0394604317843914,0.03103732503950596,0.01669362559914589,0.0316171757876873,0.03836176544427872,0.04940946772694588,0.06155583262443542,0.03646961972117424,0.01364177372306585,0.001464888453483582,-0.02084414288401604,-0.01669362559914589,0.02279732748866081,0.0274971779435873,0.02200384624302387,0.03881954401731491,0.01324503310024738,0.01709036529064178,0.0395825058221817,0.04168828576803207,0.02829065918922424,0.002349925227463245,0.005279702134430408,-0.003784295171499252,0.008911404758691788,0.004333628341555595,-0.01666310615837574,-0.06793420016765594,-0.07892086356878281,-0.0555131696164608,-0.06088442727923393,-0.07724234461784363,-0.079317606985569,-0.09887997061014175,-0.1011078208684921,-0.08450575172901154,-0.08908353000879288,-0.08267464488744736,-0.05432294681668282,-0.04327524825930595,-0.04235969111323357,-0.02526932582259178,-0.00357066560536623,-0.02105777151882648,0.004028443247079849,-0.006897183135151863,-0.009186071343719959,-0.008514664135873318,0.01171910762786865,0.01330607011914253,0.01568651385605335,-0.01538132876157761,-0.0317697674036026,0.003540147095918655,0.01989806815981865,0.01336710713803768,0.01470992155373096,0.007019257172942162,-0.002716147340834141,-0.00753807183355093,0.01483199559152126,0.01263466291129589,0.04882961511611938,0.06711020320653915,0.04306161776185036,0.02697836235165596,0.0239265114068985,0.04507583752274513,0.05349894613027573,0.05471968650817871,0.0393383577466011,0.02545243687927723,0.01553392130881548,-0.01077303383499384,-0.02835169620811939,-0.0004882961511611938,0.007293923757970333,-0.005615405738353729,-0.02072206884622574,-0.04556413367390633,-0.03662221133708954,-0.03756828606128693,-0.02508621476590633,-0.03863643482327461,-0.07879879325628281,-0.08426160365343094,-0.08355967700481415,-0.07089449465274811,-0.07687612622976303,-0.06302072107791901,-0.0477004311978817,-0.0553910955786705,-0.06012146547436714,-0.05627613142132759,-0.06057924032211304,-0.03341776877641678,-0.04348887503147125,-0.06534013152122498,-0.05435346439480782,-0.0713827908039093,-0.04666280001401901,-0.02966399118304253,-0.03097628802061081,0.01275673694908619,0.06860560923814774,0.04303110018372536,0.07077242434024811,0.09039582312107086,0.1163670793175697,0.1315347701311111,0.1098361164331436,0.08514664322137833,0.05410931631922722,0.0556047260761261,0.05658131837844849,0.0558488741517067,0.03921628370881081,0.01171910762786865,0.0003357036039233208,-0.007385479286313057,-0.0240180678665638,-0.02331614121794701,0.01785332895815372,0.04177983850240707,0.04855494946241379,0.05423139035701752,0.0790734589099884,0.1027863398194313,0.08355967700481415,0.05618457496166229,0.03064058348536491,0.007415997795760632,-0.01385540328919888,-0.06393627822399139,-0.07052827626466751,-0.07626575231552124,-0.1033661887049675,-0.1227454468607903,-0.1353190690279007,-0.1167332977056503,-0.06985686719417572,-0.03411969542503357,-0.02059999480843544,-0.01794488355517387,0.02002014219760895,0.05914487317204475,0.09302041679620743,0.08618427067995071,0.0791650116443634,0.1051057502627373,0.1294900327920914,0.1114536002278328,0.07397686690092087,0.04055909812450409,0.04016235843300819,-0.02322458662092686,-0.05713064968585968,-0.06387524306774139,-0.05862605571746826,-0.04370250552892685,-0.02905362099409103,-0.01297036651521921,-0.01702932827174664,-0.05102694779634476,-0.04449598863720894,-0.0553300566971302,-0.0637836828827858,-0.09286782145500183,-0.07190161198377609,-0.07083345949649811,-0.05661183595657349,-0.01208532974123955,-0.03250221163034439,-0.03549302741885185,-0.01882992126047611,-0.001831110566854477,0.005096591077744961,-0.003021332435309887,0.0138248847797513,0.03018280677497387,0.06006042659282684,0.06711020320653915,0.06811731308698654,0.08429212123155594,0.07217627763748169,0.07388531416654587,0.09607227146625519,0.08670308440923691,0.06091494485735893,0.07824946194887161,0.07754753530025482,0.07010101526975632,0.047853022813797,0.04257332161068916,0.03482161834836006,0.02322458662092686,0.01235999632626772,-0.0119022186845541,0.0121463667601347,0.01501510664820671,0.012268440797925,0.01754814386367798,0.03671376779675484,0.04611346870660782,0.03317362070083618,0.04217658191919327,0.008087405003607273,-0.01077303383499384,-0.03311258181929588,-0.05081331729888916,-0.07364116609096527,-0.110843226313591,-0.1005584895610809,-0.09256263822317123,-0.1048005595803261,-0.1038239672780037,-0.09625537693500519,-0.08886989951133728,-0.07061982899904251,-0.05734428018331528,-0.06030457466840744,-0.08368175476789474,-0.08539079129695892,-0.05038606002926826,-0.01284829247742891,0.01321451459079981,-0.001159703359007835,0.001281777396798134,0.01126132998615503,0.007873775437474251,0.03320413827896118,0.01922666095197201,0.04651020839810371,0.04251228272914886,0.03280739858746529,0.05417035520076752,0.07770012319087982,0.07409894466400146,0.07785271853208542,0.09018219262361526,0.0948820486664772,0.09378337860107422,0.1102938950061798,0.1080660447478294,0.1010162681341171,0.1040986329317093,0.05752738937735558,0.04611346870660782,0.0202032532542944,-0.008972441777586937,-0.03399762138724327,-0.05975524336099625,-0.06448560953140259,-0.06125064939260483,-0.08584856986999512,-0.09414960443973541,-0.09887997061014175,-0.09469893574714661,-0.1024506390094757,-0.09463790059089661,-0.06692709028720856,-0.04574724659323692,-0.05005035549402237,-0.06604205816984177,-0.06781212985515594,-0.06906338781118393,-0.03106784261763096,0.007751701399683952,-0.007415997795760632,-0.02084414288401604,-0.04040650650858879,-0.03885006159543991,-0.01480147708207369,0.02462843805551529,0.0319223627448082,0.05020294710993767,0.04181035980582237,0.06250190734863281,0.06009094417095184,0.09820856153964996,0.1193884089589119,0.09778130799531937,0.09286782145500183,0.08960234373807907,0.0709555372595787,0.03772087767720222,0.02337717823684216,0.01379436627030373,0.007751701399683952,0.005981627851724625,-0.03308206424117088,-0.0715048685669899,-0.04498428478837013,-0.02243110537528992,-0.03323465585708618,-0.05841242894530296,-0.03500473126769066,-0.01489303261041641,-0.02475051209330559,-0.02734458446502686,-0.04876857995986938,-0.05154576152563095,-0.0392468050122261,-0.02294991910457611,-0.03793450817465782,-0.04538102447986603,-0.04116946831345558,-0.04901272803544998,-0.0559099093079567,-0.01449629198759794,-0.02423169650137424,-0.0321054719388485,-0.0477614663541317,-0.05221717059612274,-0.06622516363859177,-0.06039613112807274,-0.03530991449952126,-0.01101718191057444,-0.02478102967143059,-0.04614398628473282,-0.04574724659323692,-0.02703939937055111,0.0008239997550845146,0.01644947752356529,0.01351969968527555,0.006897183135151863,0.03723258152604103,0.0870082676410675,0.1054719686508179,0.1078218966722488,0.1213415935635567,0.09775078296661377,0.1051667854189873,0.09393597394227982,0.108401745557785,0.1220130026340485,0.1192052960395813,0.08325449377298355,0.05188146606087685,0.04467909783124924,0.04959257692098618,0.06396679580211639,0.03079317696392536,0.007415997795760632,-0.02374340035021305,-0.05114902183413506,-0.02240058593451977,-0.04245124757289886,-0.05169835686683655,-0.06131168454885483,-0.0631122812628746,-0.06152531504631042,-0.05880916863679886,-0.04397717118263245,-0.07351908832788467,-0.107058934867382,-0.1168553754687309,-0.1176793724298477,-0.09216590225696564,-0.07745597511529922,-0.06210516765713692,-0.03357036039233208,-0.04602191224694252,-0.0556657612323761,-0.04119998961687088,-0.03573717549443245,-0.0235297717154026,-0.04217658191919327,-0.03735465556383133,-0.0116580706089735,-0.01477095857262611,-0.01895199529826641,-0.005920590832829475,0.003479110077023506,0.001953184604644775,-0.01211584825068712,-0.0001831110566854477,0.005493331700563431,0.005066072568297386,0.01489303261041641,0.05771050229668617,0.05206457898020744,0.05102694779634476,0.05328531935811043,0.05206457898020744,0.0875576063990593,0.1333964020013809,0.1164586320519447,0.08005005121231079,0.05929746478796005,0.04666280001401901,0.06048768758773804,0.0318308062851429,0.008087405003607273,0.007599108852446079,-0.01068147830665112,-0.03271584212779999,-0.02948088012635708,-0.05261391028761864,-0.1051973029971123,-0.1029999703168869,-0.0952177494764328,-0.07690664380788803,-0.03872798755764961,-0.02246162295341492,-0.01116977445781231,-0.004425183869898319,0.007019257172942162,-0.01409955136477947,-0.00277718435972929,0.02032532729208469,0.02200384624302387,-0.002929776906967163,-0.03341776877641678,-0.01391644030809402,0.01773125492036343,0.02835169620811939,-0.01593066193163395,-0.0102237006649375,0.005920590832829475,0.008667256683111191,-0.004058961756527424,-0.007904293946921825,-0.00872829370200634,-0.01538132876157761,-0.03610339760780334,-0.04571672901511192,-0.003845332190394402,0.03076265752315521,0.02508621476590633,-0.0277718435972929,-0.02041688375174999,0.02966399118304253,0.05645924434065819,0.04669332131743431,0.0476393923163414,0.06491287052631378,0.0633259043097496,0.06091494485735893,0.07199316471815109,0.0637226477265358,0.06808679550886154,0.0877407118678093,0.08160649240016937,0.06878872215747833,0.05496383458375931,0.04379406198859215,0.04370250552892685,0.04681539535522461,0.01132236700505018,-0.02468947507441044,-0.03500473126769066,-0.05319376289844513,-0.06122013181447983,-0.05197302252054214,-0.05392620712518692,-0.0875881239771843,-0.09860530495643616,-0.06909390538930893,-0.06216620281338692,-0.07290872186422348,-0.07666249573230743,-0.05438398569822311,-0.01123081147670746,-0.01693777367472649,-0.02780236303806305,-0.02768028900027275,-0.03500473126769066,-0.0005493331700563431,0.01477095857262611,0.03573717549443245,0.04995879903435707,0.07074190676212311,0.06048768758773804,0.06534013152122498,0.1051362678408623,0.07434309273958206,0.06244087219238281,0.04562517255544662,0.03817865625023842,0.03573717549443245,0.03488265722990036,0.0239265114068985,0.0003357036039233208,0.01077303383499384,-0.01678518019616604,-0.03778191655874252,-0.0157170332968235,-0.02471999265253544,-0.04266487807035446,-0.02871791832149029,-0.04504531994462013,-0.0393078401684761,-0.02804651111364365,-0.04123050719499588,-0.07385479658842087,-0.0954924151301384,-0.08221686631441116,-0.06122013181447983,-0.05825983360409737,-0.03402813896536827,-0.06619464606046677,-0.0475478395819664,-0.02722251042723656,0.001281777396798134,0.01046784874051809,0.02084414288401604,0.02059999480843544,0.01538132876157761,0.03640858083963394,0.0474257655441761,0.02423169650137424,0.01080355234444141,0.02038636431097984,0.01336710713803768,0.02050843834877014,0.003204443491995335,0.006286812946200371,0.003997924737632275,-0.01837214268743992,-0.02371288277208805,-0.00634784996509552,0.002319406718015671,-0.01437421794980764,0.01568651385605335,0.008911404758691788,-0.01007110811769962,-0.01785332895815372,-0.01519821770489216,-0.005737479776144028,0.001007110811769962,-0.03521836176514626,-0.01898251287639141,-0.0159916989505291,-0.03045747242867947,-0.04556413367390633,-0.04855494946241379,-0.02276680804789066,0.01788384653627872,0.01818903163075447,-0.02038636431097984,-0.03769036009907722,-0.02575762197375298,0.003357036039233208,0.009216589853167534,-0.04660176485776901,-0.05334635451436043,-0.04861598461866379,-0.0557268001139164,-0.04312265291810036,-0.03097628802061081,-0.01721243932843208,-0.0313730277121067,-0.0200506616383791,-0.001037629321217537,-0.004669331945478916,-0.01931821741163731,0.003601184114813805,0.01736503280699253,0.02395703084766865,0.05063020810484886,0.04864650592207909,0.04672383889555931,0.02725302986800671,0.01351969968527555,-0.007812738418579102,-0.007812738418579102,-0.02279732748866081,-0.02874843589961529,-0.04260383918881416,-0.02053895778954029,0.00912503432482481,0.006897183135151863,0.04272591322660446,0.04174932092428207,0.02093569748103619,0.006591998040676117,0.001129184849560261,-0.00357066560536623,-0.02710043638944626,-0.04709006100893021,-0.05832087248563766,-0.02859584428369999,0.002807702869176865,-0.007904293946921825,-0.04327524825930595,-0.0634174644947052,-0.02963347360491753,-0.02963347360491753,-0.03573717549443245,-0.0194708090275526,-0.007568590342998505,-0.01663258858025074,-0.02285836450755596,-0.01803644001483917,-0.01593066193163395,-0.03509628772735596,-0.02780236303806305,-0.0140690328553319,-0.05978576093912125,-0.0710470899939537,-0.05990783497691154,-0.04327524825930595,-0.07211523503065109,-0.04522843286395073,-0.02066103182733059,-0.02713095583021641,-0.006286812946200371,0.01965392008423805,0.01049836724996567,0.02710043638944626,0.03396710008382797,0.0554216131567955,0.08542130887508392,0.1178014501929283,0.1503646969795227,0.1358989179134369,0.1263771504163742,0.1311380416154861,0.1029084175825119,0.07394634932279587,0.05865657702088356,0.008911404758691788,-0.006683553569018841,-0.02661214023828506,-0.05258339270949364,-0.06674397736787796,-0.1041901931166649,-0.1044648587703705,-0.1245155185461044,-0.1314126998186111,-0.1057161167263985,-0.06222724169492722,-0.07202368229627609,-0.03784295171499252,0.02713095583021641,0.02658162266016006,-0.00039674062281847,0.01290932949632406,0.04104739427566528,0.02041688375174999,0.039613027125597,0.04068117216229439,0.0710776075720787,0.06250190734863281,0.05743583664298058,0.07809686660766602,0.07049775868654251,0.05627613142132759,0.04361094906926155,0.03787346929311752,0.03445539623498917,0.04669332131743431,0.01629688404500484,0.01413006987422705,-0.01235999632626772,-0.02560503035783768,-0.04419080168008804,-0.05725272372364998,-0.0718100517988205,-0.07202368229627609,-0.04541154205799103,-0.06292916834354401,-0.06259346008300781,-0.03732413798570633,-0.03473006561398506,-0.003204443491995335,0.003265480510890484,0.004119998775422573,0.009277626872062683,0.02450636401772499,6.103701889514923e-05,0.009979552589356899,-0.006927701644599438,-0.0394604317843914,-0.0472426526248455,-0.06811731308698654,-0.05688650161027908,-0.003753776662051678,0.004913480021059513,0.0160832554101944,0.01235999632626772,0.01397747732698917,0.02520828880369663,0.001739555038511753,-0.005188146606087685,0.04705954343080521,0.05304117128252983,0.04412976652383804,0.05026398599147797,0.0397656187415123,0.03842280432581902,0.02117984555661678,0.006042664870619774,0.02087466046214104,0.02645954862236977,0.01812799461185932,-0.03537095338106155,-0.02511673420667648,-0.03454695269465446,0.01147495955228806,0.02179021574556828,-0.01031525619328022,-0.007385479286313057,-0.003936887718737125,-0.002044740132987499,0.003936887718737125,0.01977599412202835,-0.01016266364604235,-0.01647999510169029,-0.001831110566854477,-0.02584917843341827,-0.001831110566854477,-0.004882961511611938,-0.03262428566813469,-0.007721182890236378,-0.01315347757190466,-0.02450636401772499,0.001098666340112686,-0.02209540084004402,-0.02053895778954029,-0.01916562393307686,-0.0117801446467638,0.00952177494764328,-0.008056886494159698,-0.03082369454205036,-0.0318918414413929,-0.004943998530507088,0.02383495680987835,0.005127109587192535,-0.01168858911842108,0.004943998530507088,0.01907406933605671,0.02197332680225372,0.03808709979057312,0.04303110018372536,0.04824976250529289,0.04916531965136528,0.03866695240139961,0.02728354744613171,-0.01709036529064178,-0.02383495680987835,-0.04980620741844177,-0.0473647266626358,-0.006286812946200371,-0.009582811966538429,-0.05615405738353729,-0.05255287513136864,-0.02734458446502686,-0.0321359895169735,-0.04562517255544662,-0.0241401419043541,0.01852473616600037,0.01315347757190466,0.02081362344324589,0.02658162266016006,0.01062044128775597,-0.001037629321217537,-0.0475783571600914,-0.02215643785893917,-0.007171849720180035,-0.02453688159584999,-0.01403851434588432,-0.0395519882440567,-0.06912442296743393,-0.0393688790500164,-0.04943998530507088,-0.06906338781118393,-0.07193212956190109,-0.05279702320694923,-0.01739555038511753,-0.01080355234444141,0.0395214706659317,0.05676442757248878,0.03506576642394066,0.08529923111200333,0.07861568033695221,0.04705954343080521,0.03787346929311752,0.03445539623498917,0.04669332131743431,0.01657155156135559,0.01721243932843208,0.01864681020379066,-0.02182073518633842,-0.04956205934286118,-0.08868678659200668,-0.0949430838227272,-0.06881923973560333,-0.09344767779111862,-0.09369182586669922,-0.08252204954624176,-0.04425184056162834,-0.0557268001139164,-0.09256263822317123,-0.04083376750349998,-0.02862636186182499,0.02554399333894253,0.02212592028081417,-0.007110812701284885,-0.01290932949632406,-0.02963347360491753,-0.03122043609619141,-0.01126132998615503,-0.03784295171499252,-0.03796502575278282,-0.03488265722990036,-0.0869167149066925,-0.07016205042600632,-0.06686605513095856,-0.03668325021862984,-0.0556047260761261,-0.05398724228143692,-0.04513687640428543,-0.0313119925558567,-0.002502517774701118,0.003692739643156528,0.02334666065871716,0.04223761707544327,0.06030457466840744,0.07669301331043243,0.07351908832788467,0.07327494025230408,0.09118930995464325,0.125888854265213,0.1019013002514839,0.09872737526893616,0.09430219233036041,0.09222693741321564,0.09854426980018616,0.07779168337583542,0.05499435588717461,0.05914487317204475,0.07696767896413803,0.0313730277121067,0.04199346899986267,0.05780205875635147,0.05792413279414177,0.05130161345005035,0.0475478395819664,0.008423108607530594,-0.05835139006376266,-0.07824946194887161,-0.09720145165920258,-0.1208532974123955,-0.1564989238977432,-0.1752372831106186,-0.1799371391534805,-0.1451460272073746,-0.110873743891716,-0.1056550815701485,-0.1079744845628738,-0.05438398569822311,-0.06292916834354401,-0.08957182615995407,-0.03094576857984066,0.04876857995986938,0.0557878352701664,0.07016205042600632,0.08346812427043915,0.07235938310623169,0.04489272832870483,0.03827021270990372,-9.155552834272385e-05,-0.00277718435972929,-0.03848383948206902,-0.06259346008300781,-0.03512680530548096,-0.05368205904960632,-0.02621540054678917,-0.01770073547959328,-0.01065095979720354,0.0001831110566854477,0.04510635882616043,0.08801538497209549,0.1358684003353119,0.1511581838130951,0.1823786199092865,0.1741996556520462,0.1854915022850037,0.1875057220458984,0.1667531430721283,0.1877803951501846,0.176152840256691,0.1532029211521149,0.07785271853208542,0.04565569013357162,0.01916562393307686,-0.05404828116297722,-0.1054109334945679,-0.1324503272771835,-0.1355021893978119,-0.1127353757619858,-0.1159703359007835,-0.1294900327920914,-0.1330607086420059,-0.1075167059898376,-0.09112826734781265,-0.1202734485268593,-0.1381572932004929,-0.1046784892678261,-0.0477004311978817,0.01141392253339291,0.0117801446467638,0.003326517529785633,0.01330607011914253,0.04886013269424438,0.06903287023305893,0.03540147095918655,0.04861598461866379,0.0395214706659317,0.05832087248563766,0.04480117186903954,0.06521805375814438,0.09366130828857422,0.05661183595657349,0.03225806355476379,0.005462813191115856,0.007690664380788803,0.05401776358485222,-9.155552834272385e-05,0.009826960042119026,-0.01278725545853376,-0.006988738663494587,-0.01553392130881548,-0.004974517039954662,0.001312295906245708,-0.007446516305208206,-0.02465895563364029,-0.06704916805028915,-0.06237983331084251,-0.08410901576280594,-0.0789819061756134,-0.06259346008300781,-0.05282754078507423,-0.07263405621051788,-0.07452619820833206,-0.04565569013357162,-0.07675404846668243,-0.07516708970069885,-0.0631427988409996,-0.05484176054596901,-0.03448591753840446,-0.02566606737673283,-0.02972502820193768,-0.007446516305208206,-0.02743614092469215,-0.01666310615837574,0.04123050719499588,0.04992828145623207,0.03601184114813805,0.04852443188428879,0.04330576583743095,0.06140324100852013,0.04812768846750259,0.06390576064586639,0.04293954372406006,0.04849391058087349,0.07583849877119064,0.07266457378864288,0.04107791557908058,0.04416028410196304,0.06735435128211975,0.04846339300274849,0.04254280403256416,0.03488265722990036,0.01046784874051809,0.02551347389817238,0.02044740132987499,0.02328562363982201,-0.01345866266638041,-0.05227820575237274,-0.06744590401649475,-0.04608295112848282,-0.03305154666304588,-0.02877895534038544,-0.06027405709028244,-0.0633869469165802,-0.09234900772571564,-0.07654042541980743,-0.02829065918922424,-0.01681569963693619,-0.04644917324185371,-0.05813775956630707,-0.0316476933658123,-0.02795495465397835,-0.01632740348577499,-0.02694784477353096,-0.05136265233159065,-0.04058961942791939,-0.06625568121671677,-0.1199377402663231,-0.06439405679702759,-0.06741538643836975,-0.07797478884458542,-0.08896145224571228,-0.08307138085365295,-0.0795617550611496,-0.1179845556616783,-0.06927701830863953,-0.05697805806994438,-0.07312235236167908,-0.1001617461442947,-0.05777153745293617,0.007415997795760632,0.02496414072811604,0.03357036039233208,0.05865657702088356,0.1242103353142738,0.09762871265411377,0.1027863398194313,0.08886989951133728,0.01922666095197201,-0.02642902918159962,-0.04187139496207237,0.02874843589961529,-0.0004272591322660446,-0.08584856986999512,-0.07339701801538467,-0.03830073028802872,-0.04272591322660446,-0.05697805806994438,-0.0115359965711832,0.0009155552834272385,-0.006622516550123692,0.005737479776144028,0.03274635970592499,0.07232886552810669,0.1085543408989906,0.123477891087532,0.06460768729448318,0.01293984800577164,-0.002410962246358395,-0.02471999265253544,-0.06271553784608841,-0.07223731279373169,-0.06161687150597572,-0.08313242346048355,-0.1298562586307526,-0.09256263822317123,-0.04086428508162498,0.02706991881132126,0.03479110077023506,0.01147495955228806,0.06500442326068878,0.01666310615837574,0.03707998991012573,0.06881923973560333,0.07089449465274811,0.07037568092346191,0.02331614121794701,0.007477034814655781,0.02853480726480484,-0.03689687699079514,-0.09115878492593765,-0.06494338810443878,-0.02658162266016006,-0.02560503035783768,-0.01144444104284048,0.02044740132987499,0.005005035549402237,-0.02169866114854813,-0.0009155552834272385,0.02984710223972797,0.06524857133626938,0.02865688130259514,0.06161687150597572,0.08551286160945892,0.03314310312271118,0.03091525100171566,0.06527908891439438,-0.004242072813212872,-0.04315317422151566,-0.0475783571600914,-0.0475173182785511,-0.03381450846791267,-0.0005493331700563431,-0.02050843834877014,-0.03894161805510521,-0.03604235872626305,-0.02307199314236641,0.009369182400405407,0.006134220398962498,0.04519791156053543,0.05233924463391304,0.01937925443053246,0.07003998011350632,0.08810693770647049,0.07461775839328766,0.05795465037226677,0.04461806267499924,0.03509628772735596,0.01873836480081081,0.06427197903394699,0.1153904870152473,0.05725272372364998,0.03369243443012238,0.01855525374412537,0.004882961511611938,-0.001617481000721455,0.01089510787278414,0.06045716628432274,0.07324442267417908,0.05377361550927162,-0.003509628586471081,-0.001312295906245708,0.02270577102899551,0.0139469588175416,0.02273629046976566,0.002014221623539925,-0.02093569748103619,-0.02899258397519588,-0.0397961363196373,-0.08096560835838318,-0.06616412848234177,-0.07513657212257385,-0.1037324145436287,-0.07895138114690781,-0.09823907911777496,-0.06689657270908356,-0.03543198853731155,-0.01028473768383265,0.02203436382114887,0.04239020869135857,0.05893124267458916,0.0713827908039093,0.08929716050624847,0.08932767808437347,0.06738486886024475,0.0711081251502037,0.06033509224653244,0.08017212152481079,0.02929776906967163,0.008545182645320892,0.02838221378624439,-0.0005798516795039177,-0.04565569013357162,-0.01763969846069813,0.01815851405262947,-0.008026367984712124,-0.002899258397519588,-0.02685628831386566,-0.02487258613109589,-0.02185125276446342,-0.0162358470261097,-0.02224799431860447,-0.01501510664820671,0.02713095583021641,0.02533036284148693,-0.002960295416414738,0.002166814170777798,-0.02450636401772499,-0.04351939633488655,-0.04943998530507088,-0.07040619850158691,-0.02105777151882648,0.007019257172942162,0.01605273596942425,0.008270516060292721,0.006805627606809139,0.01565599627792835,0.006591998040676117,-0.02349925227463245,0.02310251258313656,0.03704947233200073,0.001922666095197201,0.0196844395250082,0.07010101526975632,0.1117893010377884,0.07596056908369064,0.001617481000721455,0.006653035059571266,0.02063051238656044,0.0556657612323761,0.02261421643197536,-0.01437421794980764,0.01065095979720354,0.02267525345087051,0.02636799216270447,-0.01065095979720354,0.009186071343719959,-0.01110873743891716,-0.03491317480802536,0.03103732503950596,0.07602160423994064,0.01553392130881548,-0.01293984800577164,-0.01666310615837574,-0.03491317480802536,-0.01931821741163731,-0.04019287601113319,-0.02444532699882984,-0.008941923268139362,0.07550279051065445,0.07876827567815781,0.02905362099409103,0.01297036651521921,0.005859553813934326,0.005371257662773132,0.02688680775463581,0.0394909530878067,0.012268440797925,0.02719199284911156,-0.01355021819472313,-0.006103701889514923,0.04434339329600334,0.03006073273718357,0.004577776417136192,-0.02059999480843544,-0.005066072568297386,0.01821955107152462,0.05121006071567535,0.06436353921890259,0.05484176054596901,0.04489272832870483,0.03619495406746864,-0.03057954646646976,-0.04638813436031342,-0.02972502820193768,-0.03762932121753693,-0.03625598922371864,-0.02014221623539925,-0.012268440797925,-0.02517777122557163,-0.002105777151882648,0.03576769307255745,0.06503494083881378,0.0555742047727108,0.05603198334574699,0.1104770079255104,0.1250953674316406,0.1293069273233414,0.09286782145500183,0.08377330750226974,0.03833124786615372,0.03033539839088917,0.02462843805551529,0.04400769248604774,-0.007995849475264549,-0.01205481123179197,-0.03238013759255409,-0.08429212123155594,-0.0713827908039093,-0.07455671578645706,-0.08447523415088654,-0.06518753618001938,-0.04821924492716789,-0.009186071343719959,0.009216589853167534,0.002746665850281715,0.01364177372306585,0.01434369944036007,0.02597125247120857,0.01556443981826305,-0.01351969968527555,0.02276680804789066,0.05706961452960968,0.03802606463432312,-0.003906369209289551,-0.0241706594824791,0.01150547806173563,0.01385540328919888,-0.0392773225903511,-0.04141361638903618,0.01257362589240074,-0.0120242927223444,-0.06265450268983841,-0.01724295876920223,-6.103701889514923e-05,-0.03082369454205036,-0.03326517716050148,-0.03701895102858543,0.01092562638223171,0.05835139006376266,0.006042664870619774,0.01416058838367462,0.03424176946282387,0.06677450239658356,0.07440412789583206,0.02859584428369999,0.0135807367041707,-0.03747672960162163,0.01403851434588432,0.04434339329600334,-0.00952177494764328,-0.00119022186845541,-0.01950132846832275,-0.04904324561357498,-0.06054872274398804,-0.09662160277366638,-0.07544175535440445,-0.04940946772694588,-0.07678457349538803,-0.08624530583620071,-0.08856471627950668,-0.126102477312088,-0.1012298986315727,-0.09909360110759735,-0.09073153138160706,-0.09768974781036377,-0.05957213044166565,-0.02981658466160297,-0.03799554333090782,0.02279732748866081,0.06765953451395035,0.06094546243548393,0.03833124786615372,0.05233924463391304,0.1081575974822044,0.1303750723600388,0.1337321102619171,0.08285775035619736,0.04464858025312424,0.05844294652342796,0.02526932582259178,0.04620502516627312,0.05175939202308655,0.03234962001442909,0.05377361550927162,0.04275643080472946,0.02652058564126492,0.02072206884622574,0.04446546733379364,0.02233954891562462,-0.01272621843963861,0.006042664870619774,0.02652058564126492,0.006042664870619774,-0.04028443247079849,-0.03225806355476379,-0.05655079707503319,-0.03070162050426006,-0.1146885603666306,-0.08359019458293915,0.002441480755805969,0.02218695729970932,0.04428235813975334,0.02136295661330223,0.04553361609578133,0.03769036009907722,0.0320444367825985,0.04394665360450745,-0.007568590342998505,-0.005401776172220707,0.04104739427566528,0.06308175623416901,-0.0121463667601347,-0.07336650043725967,-0.006897183135151863,-0.04132206365466118,-0.06988738477230072,-0.02157658711075783,-0.0002441480755805969,-0.03262428566813469,0.01181066315621138,0.01535081025213003,-0.04980620741844177,-0.08188115805387497,-0.04196295142173767,-0.02932828851044178,-0.03750724717974663,-0.09448530524969101,-0.08844263851642609,-0.09234900772571564,-0.113223671913147,-0.04269539564847946,0.01126132998615503,0.01809747703373432,-0.03363139927387238,0.0004577776417136192,0.05792413279414177,0.09949034452438354,0.0871913805603981,0.1091036722064018,0.141056552529335,0.1061738952994347,0.09961241483688354,0.08285775035619736,0.04477065429091454,0.04068117216229439,0.0479445792734623,0.001495406962931156,-0.03378399088978767,-0.05789361149072647,-0.02032532729208469,-0.04495376348495483,-0.031525619328022,0.01080355234444141,-0.002075258642435074,-0.03482161834836006,0.0006714072078466415,0.01712088473141193,0.02627643756568432,0.005066072568297386,-0.04559465497732162,-0.01428266242146492,0.009399700909852982,0.007599108852446079,0.0554521307349205,0.01785332895815372,-0.04495376348495483,-0.02838221378624439,0.02627643756568432,0.02957243658602238,0.05685598403215408,0.06793420016765594,0.09176915884017944,0.125766783952713,0.1342509239912033,0.06756798177957535,0.03463850915431976,0.04452650621533394,0.03003021329641342,0.0005493331700563431,0.01120029296725988,-0.006866664625704288,-0.02584917843341827,-0.04419080168008804,-0.04712057858705521,0.006622516550123692,-0.01199377421289682,-0.02261421643197536,-0.00674459058791399,-0.031434066593647,-0.03881954401731491,-0.01876888424158096,-0.02795495465397835,-0.04388561844825745,-0.04229865595698357,-0.03744621202349663,-0.0235297717154026,-0.06280709058046341,-0.08136234432458878,-0.09454634040594101,-0.0717184990644455,-0.0399487279355526,-0.02160710468888283,-0.02514725178480148,0.01397747732698917,0.05111850425601006,0.08380382508039474,0.07293923944234848,0.06732383370399475,0.04123050719499588,0.03292947262525558,0.08249153196811676,0.09726248681545258,0.05682546645402908,0.06552323698997498,0.06570634990930557,0.04150517284870148,0.04852443188428879,0.04116946831345558,0.01788384653627872,0.03250221163034439,0.0119022186845541,0.005371257662773132,-0.001800592057406902,-0.04843287542462349,-0.07751701772212982,-0.1158177405595779,-0.07492294162511826,-0.04889065399765968,0.01986755058169365,-0.007568590342998505,0.03387554734945297,0.03460799157619476,-0.02600177004933357,-0.009247108362615108,-0.002655110321938992,0.0313425101339817,0.0551164299249649,0.05063020810484886,0.05032502114772797,0.05902279913425446,0.07641834765672684,0.08154545724391937,0.08297982811927795,0.0635395348072052,-0.003479110077023506,-0.05859553813934326,-0.05719168856739998,-0.04272591322660446,-0.0795922726392746,-0.1033661887049675,-0.02832117676734924,-0.01705984771251678,-0.0002441480755805969,0.04876857995986938,0.01556443981826305,0.05023346841335297,0.1085543408989906,0.08850368112325668,0.09018219262361526,0.1015655994415283,0.1136814504861832,0.1383098810911179,0.1332743316888809,0.07754753530025482,0.07226783037185669,0.1187780424952507,0.1401409953832626,0.06189153715968132,0.01019318215548992,-0.039704579859972,-0.06604205816984177,-0.02197332680225372,0.007721182890236378,0.02600177004933357,0.01965392008423805,-0.04089480265974998,-0.01150547806173563,-0.02627643756568432,-0.02270577102899551,-0.04620502516627312,-0.07000946253538132,-0.0710165724158287,-0.02642902918159962,-0.06054872274398804,-0.0556352436542511,-0.05981627851724625,-0.1093783378601074,-0.140873447060585,-0.09756767749786377,-0.0636921301484108,-0.0394299142062664,0.01440473645925522,-0.01156651508063078,0.05383465066552162,0.07724234461784363,0.1098971515893936,0.06637775897979736,0.03854487836360931,0.05017242953181267,0.06497390568256378,0.08206427097320557,0.04239020869135857,0.04116946831345558,0.09247108548879623,0.07712027430534363,0.0554216131567955,0.06906338781118393,0.07382427155971527,0.008667256683111191,-0.02911465801298618,-0.02081362344324589,-0.05700857564806938,-0.005829035304486752,-0.04431287571787834,-0.05316324532032013,0.01519821770489216,-0.02520828880369663,-0.001647999510169029,0.03457747027277946,0.03088473156094551,0.0877407118678093,0.112063966691494,0.09360026568174362,0.0635090172290802,0.1008636727929115,0.1062349304556847,0.08862575143575668,0.07379375398159027,0.01397747732698917,-0.01718192175030708,0.03875850886106491,0.06106753647327423,0.06949064880609512,0.1080355271697044,0.07818841934204102,0.05151524394750595,-0.0236518457531929,-0.04629657790064812,-0.01702932827174664,-0.01699881069362164,-0.06881923973560333,-0.0789819061756134,-0.1085543408989906,-0.06704916805028915,-0.05041657760739326,-0.04016235843300819,-0.07779168337583542,-0.1063570082187653,-0.07458724081516266,-0.002136295661330223,0.06607257574796677,0.1066316738724709,0.1157567054033279,0.1198461875319481,0.031464584171772,0.08145390450954437,0.1356852948665619,0.06112857535481453,0.0101016266271472,0.04904324561357498,0.05264442786574364,0.09805597364902496,0.1653187721967697,0.08557390421628952,0.07415997982025146,0.1056855991482735,0.1378521025180817,0.1454817354679108,0.0711081251502037,-0.02465895563364029,-0.02346873469650745,-0.03061006590723991,-0.03012176975607872,-0.003692739643156528,-0.01776177249848843,0.006530961021780968,-0.06237983331084251,-0.1116061881184578,-0.107150487601757,-0.08371227234601974,-0.06176946312189102,-0.02545243687927723,-0.04553361609578133,-0.05664235353469849,-0.06585894525051117,-0.06848353892564774,-0.02041688375174999,-0.04687643051147461,-0.1102633774280548,-0.1237220391631126,-0.1189001128077507,-0.1318399608135223,-0.1249732971191406,-0.1673940271139145,-0.1927854269742966,-0.1496627777814865,-0.1773735731840134,-0.1179845556616783,-0.08401745557785034,0.004974517039954662,-0.02301095612347126,-0.07293923944234848,-0.05633717030286789,-0.04504531994462013,-0.0398876927793026,-0.06958220154047012,-0.1062959656119347,-0.07742545753717422,-0.01779229193925858,0.01519821770489216,-0.02075258642435074,0.0392773225903511,0.02157658711075783,0.05160680040717125,0.03289895504713058,0.04312265291810036,0.09262367337942123,0.08059938251972198,0.09231849014759064,0.08355967700481415,-0.03216651082038879,-0.008423108607530594,-0.05386516824364662,-0.02783288061618805,0.03479110077023506,-0.04712057858705521,-0.113254189491272,-0.1054109334945679,-0.05819879844784737,-0.06030457466840744,-0.08258308470249176,-0.08426160365343094,-0.07443464547395706,-0.07226783037185669,-0.07528916001319885,-0.08108767867088318,-0.1125827804207802,-0.1693777292966843,-0.1688894331455231,-0.04901272803544998,-0.06659138947725296,-0.02435377053916454,-0.04516739398241043,-0.08035523444414139,-0.0398876927793026,-0.008362071588635445,0.05407879874110222,0.1100802645087242,0.09817804396152496,0.0954313799738884,0.09961241483688354,0.1424604058265686,0.1554612815380096,0.1513107717037201,0.1348918080329895,0.1128574460744858,0.1425519585609436,0.1276589184999466,0.06707968562841415,0.008575701154768467,0.03680532425642014,0.04181035980582237,0.0119022186845541,0.006927701644599438,0.02465895563364029,0.07727286964654922,0.08270516246557236,0.04886013269424438,0.02649006620049477,0.02697836235165596,-0.06280709058046341,-0.1703543215990067,-0.2438123673200607,-0.2109439373016357,-0.2112796455621719,-0.2706686556339264,-0.2674337029457092,-0.2420423030853271,-0.2439344525337219,-0.2389904409646988,-0.219367042183876,-0.1381267756223679,-0.1040986329317093,-0.06769005209207535,-0.02273629046976566,0.03564561903476715,0.01266518142074347,-0.00674459058791399,-0.01855525374412537,0.01702932827174664,-0.039613027125597,-0.01913510635495186,0.03268532454967499,0.04077272862195969,0.1190527081489563,0.1616565436124802,0.2153080850839615,0.2233954966068268,0.239143043756485,0.2609332501888275,0.2160100042819977,0.108462780714035,0.006714072078466415,0.02578814141452312,0.04470961540937424,-0.0157475508749485,-0.1444746255874634,-0.1635486930608749,-0.09219641983509064,-0.01040681172162294,0.02371288277208805,0.05325479805469513,0.05151524394750595,0.1206701844930649,0.1023895964026451,0.1066621914505959,0.1719412803649902,0.1032746359705925,0.06543168425559998,-0.1000701934099197,-0.1255531460046768,-0.1403851509094238,-0.219122901558876,-0.2143009752035141,-0.2551042139530182,-0.3232520520687103,-0.2939237654209137,-0.2338328212499619,-0.1534470617771149,-0.0472121350467205,0.009582811966538429,-0.001464888453483582,0.08026368170976639,0.1519821733236313,0.1658070683479309,0.1106906309723854,0.07489242404699326,0.07650990039110184,0.1309854388237,0.1754509061574936,0.1146885603666306,0.04553361609578133,0.09634693711996078,0.0637836828827858,0.02511673420667648,0.03302102908492088,0.02621540054678917,0.01126132998615503,-0.03845332190394402,-0.05020294710993767,-0.03869746997952461,-0.0320749543607235,-0.05041657760739326,-0.08441419899463654,-0.1019623428583145,-0.08206427097320557,0.003723258152604103,-0.02136295661330223,0.003631702624261379,0.00833155307918787,-0.03820917382836342,-0.02713095583021641,-0.08603167533874512,-0.1457258760929108,-0.1046174541115761,-0.02301095612347126,-0.03421124815940857,-0.07870723307132721,-0.02914517745375633,0.0139469588175416,0.03311258181929588,-0.03842280432581902,0.06863612681627274,0.09668263792991638,0.1103854477405548,0.0473342090845108,0.04388561844825745,0.06765953451395035,0.01013214513659477,-0.06524857133626938,-0.1208227798342705,-0.1178319677710533,-0.0714438334107399,-0.08322397619485855,-0.07281716167926788,-0.0559404268860817,-0.03271584212779999,0.06579791009426117,0.08960234373807907,0.07492294162511826,0.1231727078557014,0.2227240800857544,0.1728568375110626,0.161229282617569,0.1967528313398361,0.2248603850603104,0.06619464606046677,0.02383495680987835,-0.01699881069362164,-0.07300027459859848,-0.06402783095836639,-0.08450575172901154,-0.1618396490812302,-0.1778008341789246,-0.05075228214263916,-0.04687643051147461,-0.1294900327920914,-0.1334269195795059,-0.08218634873628616,-0.05240027979016304,-0.005401776172220707,0.01736503280699253,0.06466872245073318,0.01077303383499384,-0.08792382478713989,-0.04043702408671379,-0.05917539075016975,-0.1067842617630959,-0.09790337830781937,-0.1358684003353119,-0.1101718172430992,-0.02194280922412872,0.01065095979720354,0.008270516060292721,0.03595080599188805,0.03860591351985931,0.04235969111323357,0.01895199529826641,0.01455732900649309,0.03445539623498917,0.1229895949363708,0.08642841875553131,0.02468947507441044,0.02197332680225372,0.006653035059571266,0.05111850425601006,-0.005920590832829475,-0.0636616125702858,-0.07324442267417908,-0.06164738908410072,-0.079256571829319,-0.09564501047134399,-0.08182012289762497,0.02627643756568432,0.01147495955228806,-0.031434066593647,-0.04257332161068916,0.01428266242146492,0.02105777151882648,0.01251258887350559,-0.007568590342998505,0.0392468050122261,0.1039460450410843,0.09982604533433914,0.04498428478837013,0.04510635882616043,0.06408887356519699,0.08017212152481079,0.03845332190394402,0.03415021300315857,0.003753776662051678,0.03045747242867947,0.08252204954624176,-0.01672414317727089,-0.001892147585749626,-0.09143345803022385,-0.01007110811769962,0.05178990960121155,-0.01742606982588768,-0.07419049739837646,-0.04647969081997871,-0.05117953941226006,-0.06161687150597572,-0.03576769307255745,0.01025421917438507,0.02441480755805969,0.003845332190394402,-0.06720175594091415,-0.03555406257510185,0.03564561903476715,-0.0003051850944757462,0.007110812701284885,0.01837214268743992,-0.008636738173663616,-0.02081362344324589,-0.01806695759296417,-0.00357066560536623,-0.04162724688649178,-0.02557451091706753,-0.02710043638944626,0.02194280922412872,-0.01162755209952593,-0.05664235353469849,-0.0556657612323761,-0.09231849014759064,-0.01767021790146828,0.04144413769245148,-0.02645954862236977,-0.03762932121753693,0.08319345861673355,0.08948027342557907,0.002014221623539925,-0.04098635911941528,0.01715140230953693,-0.02490310370922089,-0.008972441777586937,0.05612353980541229,0.04031495004892349,0.1031220406293869,0.09155552834272385,0.1281166970729828,0.1626636534929276,0.1052888557314873,0.0954313799738884,0.07528916001319885,0.01135288551449776,-0.0240485854446888,-0.09741508215665817,-0.1825922429561615,-0.2155522257089615,-0.1380962580442429,-0.1484420299530029,-0.1955320835113525,-0.1945554912090302,-0.09579759836196899,-0.1246070712804794,-0.1800897270441055,-0.1029694527387619,-0.0791955292224884,-0.06900235265493393,-0.06530961394309998,-0.05148472636938095,-0.05200354009866714,-0.07058931142091751,0.004089480265974998,0.008453627116978168,0.04702902212738991,0.0868556797504425,0.0554216131567955,0.03653065487742424,0.09070101380348206,0.1421857327222824,0.1989196389913559,0.156163215637207,0.143650621175766,0.1385540366172791,0.1425214409828186,0.1966612786054611,0.1874141693115234,0.156346321105957,0.1312295943498611,0.1124607101082802,0.1724906116724014,0.1642200946807861,0.06253242492675781,-0.07010101526975632,-0.02929776906967163,0.008392590098083019,0.01907406933605671,-0.0637226477265358,-0.1400494426488876,-0.1886043846607208,-0.1707510650157928,-0.1394085586071014,-0.108401745557785,-0.1426740288734436,-0.1878414303064346,-0.09787286072969437,-0.03573717549443245,-0.04556413367390633,-0.02038636431097984,-0.1146885603666306,-0.1476790606975555,-0.1189916655421257,-0.1048921197652817,-0.03888058289885521,-0.01776177249848843,-0.06045716628432274,-0.1731620281934738,-0.17404705286026,-0.02908414043486118,-0.05606250092387199,-0.02429273352026939,0.05050813406705856,0.02713095583021641,0.1556138843297958,0.2002014219760895,0.2114322334527969,0.2332529723644257,0.2319406718015671,0.2208319306373596,0.2876369655132294,0.3253578245639801,0.2981047928333282,0.3628956079483032,0.3673512935638428,0.2106387466192245,0.2475051134824753,0.2745750248432159,0.1853694319725037,0.158665731549263,0.06466872245073318,0.02099673449993134,-0.03720206394791603,-0.02090517990291119,-0.1570177376270294,-0.1809137314558029,-0.1700491309165955,-0.2724082171916962,-0.2434156388044357,-0.2621234655380249,-0.252235472202301,-0.1400494426488876,-0.1123386323451996,-0.1157261878252029,-0.0155034027993679,-0.03405865654349327,-0.114535965025425,-0.1219824850559235,-0.1112399697303772,-0.1024506390094757,-0.009552293457090855,0.1193273738026619,0.1177098900079727,0.08029419928789139,0.1328470706939697,0.04965361580252647,-0.03784295171499252,0.02282784506678581,0.1193578913807869,0.04385509714484215,-0.03512680530548096,-0.0004882961511611938,0.03686635941267014,-0.02230903133749962,-0.03317362070083618,-0.07998901605606079,-0.1189001128077507,-0.1003448590636253,-0.1479232162237167,0.02630695514380932,0.1408123970031738,0.07672353088855743,0.02203436382114887,0.05371257662773132,0.1814630627632141,0.09921567142009735,0.1209143325686455,0.04348887503147125,0.1152073740959167,0.1483504772186279,0.2238227427005768,0.1476485431194305,0.09903256595134735,0.1230506300926208,0.03576769307255745,0.01345866266638041,-0.01977599412202835,-0.08377330750226974,-0.09137241542339325,-0.0795312374830246,-0.06418042629957199,-0.05484176054596901,-0.07788323611021042,-0.0556962788105011,-0.05655079707503319,-0.1502731442451477,-0.1055940464138985,-0.1113010048866272,-0.1008941903710365,-0.07278664410114288,-0.07342753559350967,-0.06591998040676117,-0.07052827626466751,-0.0870998278260231,-0.09457685798406601,-0.06830042600631714,-0.005584887228906155,-0.05954161286354065,-0.004242072813212872,0.0318308062851429,0.04092532023787498,-0.01559495832771063,0.03765984252095222,-0.02002014219760895,-0.07995849847793579,-0.08981597423553467,-0.02151555009186268,0.04574724659323692,0.06402783095836639,0.02969451062381268,0.04281746968626976,0.1069673746824265,0.186315506696701,0.2289803773164749,0.3425702750682831,0.4019593000411987,0.2686544358730316,0.2482986003160477,0.2968840599060059,0.251838743686676,0.1569872200489044,0.1139866337180138,0.04263435676693916,0.03451643511652946,0.1296426355838776,0.1484115123748779,0.2305368185043335,0.160924106836319,0.1141392290592194,0.1662343144416809,0.1230811476707458,0.08426160365343094,0.09311196953058243,0.1208532974123955,0.06454664468765259,0.05645924434065819,-0.004730368964374065,0.003051850944757462,0.01748710684478283,-0.06790368258953094,-0.04489272832870483,-0.07257301360368729,-0.1143223345279694,-0.1385540366172791,-0.1943113505840302,-0.2008423060178757,-0.1705679446458817,-0.1512497365474701,-0.143436998128891,-0.1543321013450623,-0.1810968369245529,-0.204199343919754,-0.1315042525529861,-0.1615344732999802,-0.2003845274448395,-0.2511978447437286,-0.317606121301651,-0.1860713511705399,-0.1765190660953522,-0.1482894420623779,-0.1597338765859604,-0.04052858054637909,0.02130191959440708,-0.0277413260191679,0.1568651348352432,0.1365398168563843,0.08267464488744736,0.1058992296457291,0.03912473097443581,0.108279675245285,0.1976683884859085,0.1953489780426025,0.2380748987197876,0.3337199091911316,0.3443403542041779,0.2576677799224854,0.1875667572021484,0.1491744816303253,0.236732080578804,0.2675862908363342,0.2265694141387939,0.1920834928750992,0.109500415623188,0.07040619850158691,-0.03799554333090782,-0.1487167030572891,-0.1954710483551025,-0.2487563639879227,-0.2786644995212555,-0.3465071618556976,-0.2959074676036835,-0.2987762093544006,-0.1926633566617966,-0.1364177316427231,-0.1004974544048309,-0.1069673746824265,-0.004821924492716789,-0.02606280706822872,-0.03094576857984066,0.05475020781159401,0.01428266242146492,0.03732413798570633,0.06271553784608841,0.00277718435972929,-0.01892147585749626,-0.03018280677497387,-0.1069368571043015,-0.03686635941267014,0.03912473097443581,0.01458784751594067,-0.007232886739075184,-0.008911404758691788,0.05804620683193207,0.08163700997829437,0.1645558029413223,0.1720938682556152,0.04635761678218842,0.06616412848234177,0.08276619762182236,0.1194799616932869,0.1527756601572037,0.1469161063432693,0.06140324100852013,0.08871730417013168,0.1487777382135391,0.1978209763765335,0.1706595122814178,0.1661732792854309,0.1450544744729996,0.1875972747802734,0.2026123851537704,0.1236915215849876,0.0316476933658123,0.08346812427043915,0.1418805569410324,0.00119022186845541,-0.09924619644880295,0.003662221133708954,0.02871791832149029,0.04647969081997871,0.05270546674728394,0.0320139154791832,0.0157475508749485,0.009155552834272385,-0.0006714072078466415,-0.006775109097361565,0.016235847026]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value></value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1000</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-0.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024*10</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.8</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>200</value></param>
<param><key>ymin</key><value>-200</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*10</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>.9</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*20</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>200</value></param>
<param><key>ymin</key><value>-200</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>sig_sauer_308</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[0.07242042571306229,0.04419080168008804,-0.005859553813934326,-0.0473342090845108,-0.05426191166043282,-0.04272591322660446,-0.02822962217032909,0.0007019257172942162,0.008941923268139362,-0.01818903163075447,-0.02591021545231342,-0.007873775437474251,-0.003997924737632275,-0.02261421643197536,-0.04461806267499924,-0.047883540391922,-0.0281380657106638,-0.01168858911842108,-0.007873775437474251,0.02594073303043842,0.08426160365343094,0.1214636713266373,0.1390423327684402,0.1318704783916473,0.09305093437433243,0.04187139496207237,0.004181035794317722,0.01028473768383265,0.07370220124721527,0.1385845541954041,0.176305428147316,0.2153386026620865,0.2451857030391693,0.2552262842655182,0.2429273426532745,0.1958372741937637,0.1077608540654182,0.009308145381510258,-0.05188146606087685,-0.03900265693664551,0.04956205934286118,0.1453596651554108,0.1922360956668854,0.2027649730443954,0.1838435083627701,0.1327860355377197,0.08072146028280258,0.04928739368915558,0.02835169620811939,0.01062044128775597,0.007751701399683952,0.03451643511652946,0.0558488741517067,0.04412976652383804,0.01916562393307686,-0.01446577347815037,-0.0395214706659317,-0.03573717549443245,-0.01092562638223171,0.01702932827174664,0.03482161834836006,0.04455702379345894,0.06689657270908356,0.1029999703168869,0.1353495866060257,0.1442304700613022,0.1307412981987,0.1121860444545746,0.08899197727441788,0.05911435186862946,0.03518784046173096,0.04443494975566864,0.079256571829319,0.1194494441151619,0.1226538866758347,0.08246101438999176,0.0551164299249649,0.04614398628473282,0.0551774650812149,0.09949034452438354,0.1551561057567596,0.1823786199092865,0.1909237951040268,0.2027954906225204,0.2172917872667313,0.2074037939310074,0.1529282480478287,0.0870693102478981,0.03872798755764961,-0.01593066193163395,-0.0791955292224884,-0.1004364117980003,-0.07455671578645706,-0.04486221075057983,-0.0313119925558567,-0.01928769797086716,-0.01068147830665112,-0.01434369944036007,-0.01391644030809402,0.01089510787278414,0.05694754049181938,0.09598071128129959,0.08316294103860855,0.0316476933658123,-0.0197149571031332,-0.07837153226137161,-0.1113315224647522,-0.1035493016242981,-0.07550279051065445,-0.04531998559832573,-0.02929776906967163,0.0101016266271472,0.08990752696990967,0.1834162473678589,0.2788781523704529,0.3368022739887238,0.3393963575363159,0.3039033114910126,0.2321848273277283,0.1501510739326477,0.0875881239771843,0.04452650621533394,0.0320444367825985,0.05090487375855446,0.06781212985515594,0.0791039764881134,0.1013519689440727,0.1336100399494171,0.1396526992321014,0.128360852599144,0.1328165531158447,0.1138340383768082,0.0551774650812149,-0.01327555160969496,-0.06653035432100296,-0.09256263822317123,-0.09930723160505295,-0.09125034511089325,-0.0634479820728302,-0.02359080873429775,0.02047792077064514,0.06231879815459251,0.05963316932320595,0.002014221623539925,-0.06695760786533356,-0.1100192293524742,-0.1295510679483414,-0.156041145324707,-0.1697744727134705,-0.1572923958301544,-0.1351969987154007,-0.1245460361242294,-0.1268654465675354,-0.1279030740261078,-0.1340983361005783,-0.1424604058265686,-0.1593981683254242,-0.1821344643831253,-0.2146672010421753,-0.2430799305438995,-0.221808522939682,-0.1658070683479309,-0.09958189725875854,-0.06485183537006378,-0.1157261878252029,-0.1909848302602768,-0.2166814208030701,-0.1962950527667999,-0.1584215760231018,-0.1463667750358582,-0.1114841178059578,-0.02877895534038544,0.03427228704094887,0.08285775035619736,0.1038544848561287,0.09155552834272385,0.07504501193761826,0.05902279913425446,0.05710013210773468,0.04495376348495483,0.0004882961511611938,-0.03723258152604103,-0.02731406688690186,0.005615405738353729,0.01321451459079981,-0.002349925227463245,-0.002288888208568096,0.0197149571031332,0.03811761736869812,0.031434066593647,0.003692739643156528,-0.01760918088257313,0.009582811966538429,0.07763908803462982,0.1360515207052231,0.1534165441989899,0.1008636727929115,0.008392590098083019,-0.05203405767679214,-0.06979583203792572,-0.08413953334093094,-0.08178960531949997,-0.06418042629957199,-0.05673390999436378,-0.05145420879125595,-0.04184087738394737,-0.01718192175030708,-0.006500442512333393,0.002624591812491417,0.03610339760780334,0.08420056849718094,0.1368449926376343,0.1417279541492462,0.1046479716897011,0.06558427959680557,0.01211584825068712,-0.05758842825889587,-0.1113620400428772,-0.1241493001580238,-0.1200598180294037,-0.1219519674777985,-0.1147495955228806,-0.08380382508039474,-0.04516739398241043,-0.02929776906967163,-0.03723258152604103,-0.06295968592166901,-0.07556383311748505,-0.07535020262002945,-0.09067048877477646,-0.09344767779111862,-0.08114871382713318,-0.0632648691534996,-0.05719168856739998,-0.09256263822317123,-0.1346781849861145,-0.1496627777814865,-0.1658070683479309,-0.1734672039747238,-0.1392254382371902,-0.07513657212257385,-0.00952177494764328,0.0274971779435873,0.04959257692098618,0.05349894613027573,0.03707998991012573,0.04068117216229439,0.05478072538971901,0.05606250092387199,0.05365154147148132,0.05136265233159065,0.02508621476590633,-0.01556443981826305,-0.04312265291810036,-0.06860560923814774,-0.0874050110578537,-0.07663197815418243,-0.05038606002926826,-0.05056916922330856,-0.09604174643754959,-0.1351054459810257,-0.1197241097688675,-0.06176946312189102,0.002105777151882648,-0.0009765923023223877,-0.07654042541980743,-0.1554917991161346,-0.1918088346719742,-0.189092680811882,-0.1881771236658096,-0.2018799334764481,-0.2295297086238861,-0.2526017129421234,-0.2328257113695145,-0.1820734292268753,-0.1291848570108414,-0.08658101409673691,-0.05279702320694923,-0.01400799583643675,0.007995849475264549,-0.01043733023107052,-0.0554521307349205,-0.1058076694607735,-0.1439558118581772,-0.1446882486343384,-0.10831019282341,-0.07412946224212646,-0.06527908891439438,-0.06161687150597572,-0.03555406257510185,-0.008117923513054848,-0.01525925472378731,-0.02621540054678917,-0.01931821741163731,-0.01470992155373096,-0.002899258397519588,0.01477095857262611,0.05331583693623543,0.1039460450410843,0.1230811476707458,0.1207007020711899,0.1173741891980171,0.1229285597801208,0.1362956613302231,0.1418195068836212,0.130771815776825,0.1318094432353973,0.1423383355140686,0.1400189250707626,0.1566209942102432,0.1852778643369675,0.2052674889564514,0.2281258553266525,0.2245857119560242,0.1955626159906387,0.1541184782981873,0.08413953334093094,0.005859553813934326,-0.07666249573230743,-0.1619006991386414,-0.2172917872667313,-0.2271797806024551,-0.1987975686788559,-0.1627552062273026,-0.1632435023784637,-0.1796319484710693,-0.158482626080513,-0.1045258939266205,-0.05999939143657684,-0.05063020810484886,-0.06656087189912796,-0.0796533077955246,-0.07599108666181564,-0.07620471715927124,-0.09100619703531265,-0.09637745469808578,-0.08349864184856415,-0.06701865047216415,-0.05703909322619438,-0.05371257662773132,-0.05847346410155296,-0.09222693741321564,-0.1591235101222992,-0.2106387466192245,-0.2053590565919876,-0.1731620281934738,-0.1535996645689011,-0.145908996462822,-0.1375164091587067,-0.1297647058963776,-0.1188390776515007,-0.09286782145500183,-0.06506546586751938,-0.04663228243589401,-0.0279854740947485,-0.003692739643156528,0.003357036039233208,-0.008606219664216042,-0.009979552589356899,-0.004303109832108021,0.001709036529064178,0.006561479531228542,0.01278725545853376,0.02026429027318954,0.01379436627030373,0.008545182645320892,0.02713095583021641,0.07538072019815445,0.1243018880486488,0.1336405575275421,0.110873743891716,0.08133182674646378,0.07312235236167908,0.1035187840461731,0.1358378827571869,0.1364787817001343,0.123538926243782,0.1231116652488708,0.1365398168563843,0.1329386234283447,0.1019928604364395,0.07232886552810669,0.04849391058087349,0.02914517745375633,0.0009765923023223877,-0.03088473156094551,-0.03326517716050148,-0.009643848985433578,0.02716147340834141,0.05249183624982834,0.05911435186862946,0.05349894613027573,0.0476088747382164,0.08294931054115295,0.1383709162473679,0.1591845452785492,0.1387981772422791,0.0872218981385231,0.02059999480843544,-0.03341776877641678,-0.03097628802061081,0.02490310370922089,0.07818841934204102,0.08584856986999512,0.05941953882575035,0.03781243413686752,0.02169866114854813,0.01287881098687649,0.00555436871945858,0.005829035304486752,0.03015228733420372,0.04846339300274849,0.05639820545911789,0.07254249602556229,0.09869685769081116,0.1271706223487854,0.1405987739562988,0.1480147689580917,0.1299783289432526,0.09094516187906265,0.09103671461343765,0.1239356696605682,0.1572313606739044,0.1734061688184738,0.1565904766321182,0.1060518175363541,0.05923642590641975,0.02938932552933693,-0.0001220740377902985,-0.01965392008423805,-0.03479110077023506,-0.04873805865645409,-0.02258369699120522,0.0316171757876873,0.06439405679702759,0.08224738389253616,0.08886989951133728,0.1048005595803261,0.1466109156608582,0.1886349022388458,0.2335276305675507,0.2809534072875977,0.3316446542739868,0.3740348517894745,0.3447981178760529,0.2656331062316895,0.209051787853241,0.1565904766321182,0.079439677298069,-0.0005493331700563431,-0.05078279972076416,-0.05142368748784065,-0.03384502604603767,-0.05365154147148132,-0.11456648260355,-0.1782891303300858,-0.203894168138504,-0.2021851241588593,-0.208899199962616,-0.2423169612884521,-0.2992339730262756,-0.330118715763092,-0.3178808093070984,-0.2863246500492096,-0.256904810667038,-0.2454908937215805,-0.2276985943317413,-0.1679738759994507,-0.09070101380348206,-0.04498428478837013,-0.03015228733420372,-0.05368205904960632,-0.1034272313117981,-0.1375164091587067,-0.126194030046463,-0.05349894613027573,0.03225806355476379,0.08786278963088989,0.1376079618930817,0.1960203796625137,0.2158268988132477,0.2035584598779678,0.2022766768932343,0.2101809680461884,0.2070375680923462,0.1815851330757141,0.143620103597641,0.1179540380835533,0.1060518175363541,0.06457716971635818,0.02398754842579365,0.00833155307918787,0.01477095857262611,0.04049806296825409,0.0392468050122261,0.01504562515765429,-0.003112887963652611,0.002075258642435074,0.003326517529785633,-0.01690725423395634,-0.03653065487742424,-0.05352946743369102,-0.07055879384279251,-0.06170842796564102,-0.006530961021780968,0.03872798755764961,0.02420117892324924,-0.0162053294479847,-0.0236518457531929,-0.01754814386367798,-0.06476027518510818,-0.1481673568487167,-0.1928464621305466,-0.1963255703449249,-0.1693472117185593,-0.09842219203710556,-0.03863643482327461,-0.04196295142173767,-0.07644886523485184,-0.09164708107709885,-0.09051790088415146,-0.09616382420063019,-0.1102328598499298,-0.1090731546282768,-0.05896176025271416,0.02630695514380932,0.07049775868654251,0.06234931573271751,0.06585894525051117,0.08819849044084549,0.09338664263486862,0.08285775035619736,0.09183019399642944,0.1331522613763809,0.193914607167244,0.2111880928277969,0.1785943210124969,0.1519516557455063,0.1264687031507492,0.09350871294736862,0.05136265233159065,-0.01348918117582798,-0.1048005595803261,-0.1598864644765854,-0.1752372831106186,-0.191198468208313,-0.1774651259183884,-0.1442609876394272,-0.1150852963328362,-0.1008331552147865,-0.1016266345977783,-0.1024506390094757,-0.09472945332527161,-0.06543168425559998,-0.02591021545231342,-0.008850367739796638,0.01892147585749626,0.07318338751792908,0.09167760610580444,0.06756798177957535,0.02426221594214439,0.01220740377902985,0.06210516765713692,0.08435316383838654,0.03866695240139961,-0.006591998040676117,-0.008362071588635445,0.03122043609619141,0.07696767896413803,0.09469893574714661,0.08792382478713989,0.07544175535440445,0.08062990009784698,0.09723196923732758,0.1073336005210876,0.1238746270537376,0.1230811476707458,0.08908353000879288,0.07663197815418243,0.09985656291246414,0.108462780714035,0.08352915942668915,0.02676473371684551,-0.04300057888031006,-0.06729331612586975,-0.04538102447986603,-0.0039674062281847,0.05740531533956528,0.1051973029971123,0.1029084175825119,0.08847315609455109,0.07394634932279587,0.02288888208568096,-0.03091525100171566,-0.09701833873987198,-0.1719107627868652,-0.1903439462184906,-0.1691640913486481,-0.1543015837669373,-0.1623584777116776,-0.1860713511705399,-0.2166509032249451,-0.2279427498579025,-0.1879329830408096,-0.1152684092521667,-0.06897183507680893,-0.07434309273958206,-0.1204260364174843,-0.1875667572021484,-0.2489700019359589,-0.2686849534511566,-0.2119510471820831,-0.1138645559549332,-0.02298043854534626,0.03473006561398506,0.07425153255462646,0.1001617461442947,0.07214576005935669,0.004577776417136192,-0.06561479717493057,-0.1138950809836388,-0.1253090053796768,-0.1335795223712921,-0.1799371391534805,-0.2137821614742279,-0.2047791928052902,-0.1692861765623093,-0.1142002642154694,-0.09231849014759064,-0.1093478202819824,-0.1155735924839973,-0.1020844131708145,-0.07470931112766266,-0.03390606492757797,0.01116977445781231,0.05795465037226677,0.1130710765719414,0.1770378798246384,0.2110965251922607,0.1798150539398193,0.1098361164331436,0.04211554303765297,-0.01004058960825205,-0.01110873743891716,0.04538102447986603,0.09210485965013504,0.1290322542190552,0.1839960962533951,0.2346568256616592,0.2293771207332611,0.1569872200489044,0.06570634990930557,-0.01724295876920223,-0.06164738908410072,-0.06213568523526192,-0.06118961051106453,-0.09408856183290482,-0.14096499979496,-0.1812799423933029,-0.2078310549259186,-0.2010559439659119,-0.1655018776655197,-0.107211522758007,-0.04599139466881752,0.01434369944036007,0.06869716197252274,0.09048738330602646,0.09796441346406937,0.1007110849022865,0.09295938163995743,0.06811731308698654,0.01501510664820671,-0.03866695240139961,-0.06994842737913132,-0.09418012201786041,-0.1109653040766716,-0.1243324056267738,-0.1182897463440895,-0.09097567945718765,-0.08426160365343094,-0.06250190734863281,-0.02661214023828506,0.0156254768371582,0.0715353861451149,0.08246101438999176,0.08423108607530594,0.1047700420022011,0.08276619762182236,0.02850428782403469,0.005920590832829475,0.003265480510890484,-0.0160832554101944,-0.03729362040758133,-0.047791987657547,-0.04672383889555931,-0.01840266212821007,0.02276680804789066,0.04550309851765633,0.06863612681627274,0.07553330808877945,0.04025391489267349,-0.008301034569740295,-0.03604235872626305,-0.003814813680946827,0.08163700997829437,0.1687368452548981,0.209021270275116,0.1909848302602768,0.1608325392007828,0.1510971337556839,0.1749626100063324,0.2151554971933365,0.2310861498117447,0.1893673539161682,0.1043733060359955,0.04177983850240707,0.01666310615837574,0.01474044006317854,-0.004882961511611938,-0.04028443247079849,-0.04190191254019737,-0.03762932121753693,-0.04068117216229439,-0.0241401419043541,-0.0003051850944757462,0.002716147340834141,-0.01812799461185932,-0.03576769307255745,-0.04208502545952797,-0.05700857564806938,-0.08279671519994736,-0.1044343411922455,-0.1299783289432526,-0.1780144721269608,-0.1948606818914413,-0.128543958067894,-0.01516769919544458,0.06140324100852013,0.07061982899904251,0.04013184085488319,-0.01867732778191566,-0.06460768729448318,-0.09018219262361526,-0.1479842513799667,-0.2128971219062805,-0.2161015719175339,-0.1642811298370361,-0.08294931054115295,0.01739555038511753,0.08557390421628952,0.1102938950061798,0.1573534309864044,0.2025818675756454,0.2047181576490402,0.1815546154975891,0.1389812976121902,0.1334574371576309,0.1567430645227432,0.1663563996553421,0.1662343144416809,0.1239661872386932,0.05346842855215073,-0.00039674062281847,-0.02188177220523357,9.155552834272385e-05,0.03402813896536827,0.0633259043097496,0.08987700939178467,0.08810693770647049,0.08044679462909698,0.09656056761741638,0.1202429309487343,0.1347087025642395,0.1325724124908447,0.1019623428583145,0.05087435618042946,0.002014221623539925,-0.05108798667788506,-0.08499404788017273,-0.08001953363418579,-0.09598071128129959,-0.1532944738864899,-0.1806085407733917,-0.113376259803772,-0.01315347757190466,-0.001312295906245708,-0.07504501193761826,-0.1527451425790787,-0.1741996556520462,-0.1290932893753052,-0.05136265233159065,0.04260383918881416,0.113162636756897,0.1527146250009537,0.1909237951040268,0.1921750605106354,0.1785638034343719,0.1978514939546585,0.2057557851076126,0.1516769975423813,0.05981627851724625,-0.01440473645925522,-0.03418073058128357,0.01095614489167929,0.05505539104342461,0.06106753647327423,0.05691701918840408,0.05716116726398468,0.07080294191837311,0.08023316413164139,0.08322397619485855,0.08218634873628616,0.08496353030204773,0.08481093496084213,0.0393078401684761,-0.01263466291129589,-0.009033478796482086,0.008575701154768467,-0.00039674062281847,-0.001098666340112686,-0.01937925443053246,-0.08062990009784698,-0.1185338944196701,-0.09317301213741302,-0.05374309420585632,-0.03524887934327126,-0.01965392008423805,-0.01590014435350895,-0.01507614366710186,-0.007354960776865482,0.0202032532542944,0.03729362040758133,-0.006683553569018841,-0.02615436352789402,0.03308206424117088,0.07003998011350632,0.03659169375896454,-0.009674367494881153,-0.02728354744613171,-0.0316782146692276,-0.05114902183413506,-0.05612353980541229,-0.0637836828827858,-0.107272557914257,-0.1634876579046249,-0.2162846773862839,-0.2255928218364716,-0.2094790488481522,-0.2210455685853958,-0.2472609579563141,-0.2847071886062622,-0.3458662629127502,-0.4113894999027252,-0.4321726262569427,-0.3928647637367249,-0.3232825696468353,-0.2574846744537354,-0.2128666043281555,-0.1878109127283096,-0.1697439551353455,-0.1048921197652817,-0.00833155307918787,0.06418042629957199,0.09823907911777496,0.1036103367805481,0.1038850098848343,0.06750694662332535,0.02310251258313656,0.02722251042723656,0.05301064997911453,0.05423139035701752,0.02099673449993134,-0.01590014435350895,-0.03659169375896454,-0.04110843315720558,-0.07000946253538132,-0.1480452865362167,-0.191595196723938,-0.1473433673381805,-0.06866664439439774,-0.03274635970592499,-0.04925687611103058,-0.0394299142062664,-0.01681569963693619,-0.03280739858746529,-0.05642872303724289,-0.04434339329600334,0.01312295906245708,0.07202368229627609,0.09717093408107758,0.1122775971889496,0.1348918080329895,0.141178622841835,0.1604968458414078,0.1924497187137604,0.1824091374874115,0.1225318163633347,0.03616443276405334,-0.03003021329641342,-0.04965361580252647,-0.02908414043486118,-0.02505569718778133,-0.06964323669672012,-0.08862575143575668,-0.04977568984031677,0.006408886983990669,0.08197271823883057,0.1179540380835533,0.09097567945718765,0.08496353030204773,0.08346812427043915,0.07806634902954102,0.09845270961523056,0.09393597394227982,0.05212561413645744,0.01672414317727089,0.008789330720901489,0.03720206394791603,0.08664204925298691,0.1212805584073067,0.1196020394563675,0.09887997061014175,0.08978545665740967,0.112063966691494,0.1438032239675522,0.09689626842737198,-0.0555742047727108,-0.2164067476987839,-0.3070772290229797,-0.3245033025741577,-0.2681661546230316,-0.1316568553447723,0.03909420967102051,0.1629078090190887,0.2158574163913727,0.252265989780426,0.2674337029457092,0.2226020097732544,0.1650440990924835,0.1514023244380951,0.1873531341552734,0.252143919467926,0.3214209377765656,0.334696501493454,0.2808618545532227,0.2195196449756622,0.1873531341552734,0.1774346083402634,0.1597033590078354,0.1378521025180817,0.1237525567412376,0.1245155185461044,0.1202429309487343,0.079439677298069,0.009369182400405407,-0.05652027949690819,-0.09195227175951004,-0.1128574460744858,-0.1567430645227432,-0.2034058719873428,-0.2131717950105667,-0.2133243829011917,-0.2327646762132645,-0.2641376852989197,-0.2803735435009003,-0.2983489632606506,-0.3194067180156708,-0.3249916136264801,-0.3168736696243286,-0.2926114797592163,-0.2740562260150909,-0.2618182897567749,-0.2751548886299133,-0.2956022918224335,-0.2721945941448212,-0.193823054432869,-0.09622485935688019,-0.02804651111364365,0.04022339731454849,0.1251258850097656,0.156132698059082,0.1604358106851578,0.1962645351886749,0.204321414232254,0.1539353579282761,0.07358012348413467,0.01480147708207369,-0.003143406473100185,0.02673421427607536,0.09317301213741302,0.1529282480478287,0.1918088346719742,0.1921445429325104,0.1329386234283447,0.04596087709069252,-0.02319406718015671,-0.05365154147148132,-0.03329569473862648,-0.03701895102858543,-0.06109805777668953,-0.02865688130259514,0.01916562393307686,0.04199346899986267,0.09402752667665482,0.1873836517333984,0.2162236422300339,0.1799981743097305,0.1440778821706772,0.1236915215849876,0.1225318163633347,0.09186071157455444,0.04245124757289886,0.04269539564847946,0.07324442267417908,0.09576708078384399,0.130954921245575,0.1607104688882828,0.1472212970256805,0.1385235190391541,0.1748100221157074,0.2185735702514648,0.2412793338298798,0.2256538569927216,0.1651051342487335,0.1194494441151619,0.1291543394327164,0.1148716732859612,0.04858546704053879,-0.003906369209289551,-0.05301064997911453,-0.1311380416154861,-0.2123783081769943,-0.2491836249828339,-0.2479018568992615,-0.2015442401170731,-0.1185033693909645,-0.079378642141819,-0.1080355271697044,-0.1494491398334503,-0.1229590773582458,-0.03762932121753693,0.05157628282904625,0.1159398183226585,0.1623889952898026,0.2056642323732376,0.2290108948945999,0.2268440872430801,0.1961119472980499,0.1753288358449936,0.1721244007349014,0.1522263288497925,0.1180761158466339,0.09570604562759399,0.08239997923374176,0.05829035490751266,0.01696829125285149,-0.006134220398962498,0.002929776906967163,-0.005615405738353729,-0.01782280951738358,-0.03326517716050148,-0.03469954431056976,0.0155034027993679,0.05236976221203804,0.03579821065068245,0.001159703359007835,-0.04626606032252312,-0.1225928515195847,-0.1872920989990234,-0.1954405307769775,-0.1771294325590134,-0.1368449926376343,-0.06955168396234512,-0.02954191714525223,-0.02945036254823208,-0.01293984800577164,0.01367229223251343,-0.004791405983269215,-0.04486221075057983,-0.05444502085447311,-0.02652058564126492,-0.02502517774701118,-0.03228858485817909,0.01464888453483582,0.07797478884458542,0.1362346261739731,0.1577501744031906,0.1137730032205582,0.07480086386203766,0.079287089407444,0.08294931054115295,0.06671345978975296,0.05182043090462685,0.05166783556342125,0.04580828174948692,0.01919614337384701,-0.02844325080513954,-0.06527908891439438,-0.07400738447904587,-0.06085390970110893,-0.01678518019616604,0.04470961540937424,0.0871303454041481,0.0556352436542511,-0.07727286964654922,-0.2513809502124786,-0.382732629776001,-0.4336985349655151,-0.3905758857727051,-0.3195287883281708,-0.2919400632381439,-0.3087252378463745,-0.3055818378925323,-0.2665486633777618,-0.2540665864944458,-0.2421338558197021,-0.1949217170476913,-0.1359294354915619,-0.06295968592166901,0.03689687699079514,0.1103549301624298,0.1392864733934402,0.1424909234046936,0.1195104867219925,0.09283730387687683,0.0710470899939537,0.03897213563323021,-0.01242103334516287,-0.0558793917298317,-0.04806665331125259,-0.001129184849560261,0.06033509224653244,0.1065706387162209,0.09054841846227646,0.0790429413318634,0.1254005581140518,0.191320538520813,0.2199163734912872,0.1928769797086716,0.1728263199329376,0.1663563996553421,0.1541184782981873,0.1454817354679108,0.1366313695907593,0.1204260364174843,0.1213721111416817,0.1651356518268585,0.2259895652532578,0.2612689733505249,0.2488479316234589,0.2062745988368988,0.1620838046073914,0.1243629232048988,0.1085848584771156,0.1090121194720268,0.07248146086931229,-0.001770073547959328,-0.0869472324848175,-0.1658375859260559,-0.2289803773164749,-0.2554399371147156,-0.2226020097732544,-0.2083193510770798,-0.2293771207332611,-0.2135990411043167,-0.1509750634431839,-0.06570634990930557,0.0160832554101944,0.04416028410196304,-0.01873836480081081,-0.06564531475305557,-0.05664235353469849,-0.05600146576762199,-0.05081331729888916,-0.04232917353510857,-0.03234962001442909,-0.04815820977091789,-0.05270546674728394,0.01965392008423805,0.08926664292812347,0.1199682578444481,0.1380352228879929,0.128574475646019,0.08810693770647049,0.03253273293375969,0.01345866266638041,0.05169835686683655,0.08175908774137497,0.0557573176920414,0.04416028410196304,0.06491287052631378,0.06805627793073654,0.1104464828968048,0.1760002374649048,0.1617480963468552,0.05890072509646416,-0.0475173182785511,-0.08322397619485855,-0.05450605973601341,-0.03311258181929588,-0.05413983762264252,-0.09323404729366302,-0.1272011548280716,-0.08444471657276154,0.05240027979016304,0.1532029211521149,0.1391033679246902,0.07727286964654922,0.03042695485055447,0.02121036499738693,0.03579821065068245,0.05102694779634476,0.07568590342998505,0.09353923052549362,0.1025727093219757,0.09445478767156601,0.06067079678177834,0.05401776358485222,0.07019257545471191,0.06158635392785072,0.02981658466160297,-0.02905362099409103,-0.09308145195245743,-0.1003753766417503,-0.1055940464138985,-0.1829889863729477,-0.269234299659729,-0.3145237565040588,-0.3293862640857697,-0.2980742752552032,-0.2386547476053238,-0.1816156506538391,-0.1638538837432861,-0.2405774146318436,-0.3552354574203491,-0.3975646197795868,-0.3267922103404999,-0.2196417152881622,-0.160924106836319,-0.1364482492208481,-0.1431928426027298,-0.1479232162237167,-0.09723196923732758,-0.04629657790064812,-0.03601184114813805,-0.04596087709069252,-0.03442487865686417,0.03015228733420372,0.08514664322137833,0.08630634844303131,0.09680471569299698,0.1573839485645294,0.2401196360588074,0.2863551676273346,0.2767723500728607,0.2573931217193604,0.2261726707220078,0.1845454275608063,0.1704458743333817,0.1824396550655365,0.1833857297897339,0.1794183105230331,0.2045960873365402,0.2276375591754913,0.2221442312002182,0.1647083908319473,0.09909360110759735,0.0952482670545578,0.1020538955926895,0.05655079707503319,-0.03360087797045708,-0.1123691499233246,-0.1513412892818451,-0.1303140372037888,-0.0874355286359787,-0.08389538526535034,-0.09729301184415817,-0.1256446987390518,-0.1743522435426712,-0.2006897181272507,-0.1991027593612671,-0.1975158005952835,-0.2022461593151093,-0.2061830461025238,-0.1951353549957275,-0.1776787638664246,-0.1710562407970428,-0.1821344643831253,-0.1916867643594742,-0.2051759362220764,-0.2226630449295044,-0.2023377120494843,-0.1845149099826813,-0.1605578809976578,-0.08590960502624512,-0.0318002887070179,-0.007507553324103355,0.05462813377380371,0.1541184782981873,0.2167424559593201,0.1934263110160828,0.1451155096292496,0.1373332887887955,0.1759697198867798,0.2229682356119156,0.2004760950803757,0.1387066245079041,0.1297952234745026,0.171483501791954,0.2220526784658432,0.2540360689163208,0.2429578602313995,0.1774040907621384,0.1154210045933723,0.109714038670063,0.1324503272771835,0.1419110745191574,0.1103549301624298,0.04519791156053543,-0.02206488326191902,-0.07736442238092422,-0.1169164106249809,-0.1209753751754761,-0.09244056791067123,-0.0634784996509552,-0.05658131837844849,-0.08554337918758392,-0.08902249485254288,-0.06186101958155632,-0.07361064851284027,-0.1063264906406403,-0.1494491398334503,-0.2009338736534119,-0.2386547476053238,-0.2553483545780182,-0.2159489691257477,-0.1214331462979317,-0.0392468050122261,0.03503524884581566,0.1019013002514839,0.1170079633593559,0.1079134494066238,0.07412946224212646,-0.005279702134430408,-0.04550309851765633,-0.01818903163075447,0.01709036529064178,0.03802606463432312,0.0321359895169735,0.03387554734945297,0.07403790205717087,0.109561450779438,0.09048738330602646,0.02496414072811604,-0.027405621483922,-0.0277718435972929,0.02072206884622574,0.079439677298069,0.1007416024804115,0.08780175447463989,0.05932798236608505,0.003448591567575932,-0.03009125031530857,0.005066072568297386,0.05893124267458916,0.09192175418138504,0.07449568063020706,0.0278939176350832,-0.01760918088257313,-0.0554216131567955,-0.06100650131702423,-0.06424146145582199,-0.07586901634931564,-0.07699819654226303,-0.09903256595134735,-0.1535691469907761,-0.1671498715877533,-0.1241493001580238,-0.0393383577466011,0.03537095338106155,0.01400799583643675,-0.0279854740947485,-0.04138309881091118,-0.04205450788140297,-0.00277718435972929,0.05194250494241714,0.1056855991482735,0.1625721007585526,0.2076479345560074,0.2338328212499619,0.2281563729047775,0.1895199418067932,0.1201208531856537,0.05420087277889252,0.03109836205840111,0.005584887228906155,-0.03903317451477051,-0.0472426526248455,-0.02237006835639477,-0.03881954401731491,-0.1014740467071533,-0.1528061777353287,-0.161015659570694,-0.1293984800577164,-0.0872524157166481,-0.04501480236649513,-0.01644947752356529,-0.02407910488545895,-0.05145420879125595,-0.0718710869550705,-0.1161229312419891,-0.1580553650856018,-0.1419721096754074,-0.1012909337878227,-0.07855464518070221,-0.1172521114349365,-0.1796929836273193,-0.2316965311765671,-0.269447922706604,-0.2528763711452484,-0.206671342253685,-0.1387066245079041,-0.0556962788105011,0.00158696249127388,0.03888058289885521,0.07660146057605743,0.08584856986999512,0.08450575172901154,0.1080050021409988,0.1502426266670227,0.1931821703910828,0.1951658725738525,0.1716361045837402,0.1345561146736145,0.1074861884117126,0.1040375977754593,0.08130130916833878,0.05499435588717461,0.02276680804789066,-0.03363139927387238,-0.05868709459900856,-0.0281380657106638,0.001373332925140858,-0.007690664380788803,-0.0397656187415123,-0.08590960502624512,-0.1233863309025764,-0.1328165531158447,-0.1180761158466339,-0.09686575084924698,-0.1003448590636253,-0.08468886464834213,-0.03875850886106491,-0.005279702134430408,0.01138340402394533,0.004974517039954662,-0.0241706594824791,-0.06720175594091415,-0.09152501076459885,-0.07504501193761826,-0.05832087248563766,-0.08139286190271378,-0.1007110849022865,-0.04422131925821304,0.05337687209248543,0.1150852963328362,0.1653492897748947,0.224127933382988,0.2513809502124786,0.2636188864707947,0.2453688234090805,0.161076694726944,0.07281716167926788,0.008514664135873318,-0.03714102506637573,-0.05783257633447647,-0.05212561413645744,-0.04495376348495483,-0.06100650131702423,-0.07358012348413467,-0.06659138947725296,-0.04379406198859215,-0.04504531994462013,-0.06622516363859177,-0.04196295142173767,0.01239051483571529,0.01467940304428339,-0.04010132327675819,-0.09561449289321899,-0.1240882575511932,-0.08233893662691116,-0.01687673665583134,-0.02447584457695484,-0.06546220183372498,-0.08191168308258057,-0.06555376201868057,-0.0313119925558567,-0.01342814415693283,0.002227851189672947,0.02328562363982201,0.02090517990291119,0.02758873254060745,0.05502487346529961,0.05203405767679214,0.01687673665583134,-0.01489303261041641,-0.02630695514380932,-0.0240180678665638,-0.02627643756568432,-0.0195928830653429,-0.003082369454205036,-0.007599108852446079,-0.007599108852446079,0.02185125276446342,0.1008636727929115,0.1752067655324936,0.1933042407035828,0.1995605379343033,0.1690420210361481,0.1275063306093216,0.09863582253456116,0.06112857535481453,0.0239265114068985,-0.01821955107152462,-0.04458754137158394,-0.02780236303806305,0.02649006620049477,0.05319376289844513,0.02694784477353096,-0.001617481000721455,-0.02499466016888618,-0.07254249602556229,-0.1272621899843216,-0.1526841074228287,-0.1372417360544205,-0.1204870790243149,-0.1197546347975731,-0.09460738301277161,-0.08829005062580109,-0.1333964020013809,-0.1638538837432861,-0.1242713704705238,-0.02783288061618805,0.0554216131567955,0.07849361002445221,0.06109805777668953,0.03738517314195633,0.01654103212058544,0.01663258858025074,0.04354991391301155,0.06823939085006714,0.06836146116256714,0.06405834853649139,0.09207434207201004,0.1415448486804962,0.1616260260343552,0.1595507711172104,0.1821039468050003,0.1924497187137604,0.1518906205892563,0.1094393730163574,0.09836115688085556,0.0795617550611496,0.05392620712518692,0.05819879844784737,0.08780175447463989,0.1345255970954895,0.1709952056407928,0.1765495836734772,0.1595507711172104,0.1481063216924667,0.1443220376968384,0.1015655994415283,0.05288857594132423,0.03711050748825073,0.03506576642394066,0.02182073518633842,-0.03030488081276417,-0.05264442786574364,-0.03396710008382797,-0.05325479805469513,-0.1148716732859612,-0.1753898710012436,-0.1716971397399902,-0.128391370177269,-0.1033051535487175,-0.1085543408989906,-0.1307412981987,-0.1315347701311111,-0.1210669279098511,-0.08334604650735855,-0.01886043883860111,-0.006653035059571266,-0.05203405767679214,-0.08487197756767273,-0.08383434265851974,-0.07535020262002945,-0.07669301331043243,-0.09768974781036377,-0.1164281144738197,-0.1080355271697044,-0.08243049681186676,-0.05847346410155296,-0.04806665331125259,-0.06842249631881714,-0.09247108548879623,-0.09002960473299026,-0.07519760727882385,-0.03466902673244476,0.007446516305208206,0.0160832554101944,0.008667256683111191,0.01876888424158096,0.04837183654308319,0.05636768788099289,0.05420087277889252,0.09604174643754959,0.1631214320659637,0.1958677917718887,0.2035889774560928,0.2197332680225372,0.2136295735836029,0.1499679535627365,0.07812738418579102,0.04281746968626976,0.04910428076982498,0.08914456516504288,0.1034272313117981,0.05658131837844849,-0.02035584673285484,-0.08508560806512833,-0.1270790696144104,-0.1477095931768417,-0.1423993706703186,-0.109714038670063,-0.09192175418138504,-0.1136204078793526,-0.1498153656721115,-0.2029175758361816,-0.2139347493648529,-0.1523178815841675,-0.1057771518826485,-0.1316873729228973,-0.1683401018381119,-0.1380962580442429,-0.09442427009344101,-0.08844263851642609,-0.08642841875553131,-0.05160680040717125,0.009491256438195705,0.0716269388794899,0.08600115776062012,0.02099673449993134,-0.03323465585708618,-0.04168828576803207,-0.06503494083881378,-0.08557390421628952,-0.06634724140167236,-0.02972502820193768,0.006775109097361565,0.03857539594173431,0.01379436627030373,-0.05011139437556267,-0.06503494083881378,-0.02310251258313656,0.05243080109357834,0.1160313710570335,0.1290322542190552,0.1273537427186966,0.143620103597641,0.1366313695907593,0.09625537693500519,0.04681539535522461,0.01303140353411436,0.04174932092428207,0.08200323581695557,0.08456678688526154,0.07803583145141602,0.1013824865221977,0.1198156699538231,0.08932767808437347,0.05413983762264252,0.03030488081276417,0.02877895534038544,0.04315317422151566,0.04309213533997536,0.02313303016126156,0.01886043883860111,0.04065065458416939,0.03460799157619476,-0.02832117676734924,-0.09308145195245743,-0.0554216131567955,0.06891079246997833,0.1492049992084503,0.1420331448316574,0.1207007020711899,0.08951079100370407,0.03601184114813805,0.02285836450755596,0.04153569042682648,0.0473952442407608,0.05877865105867386,0.1079134494066238,0.1540574431419373,0.123569443821907,0.06427197903394699,0.01324503310024738,-0.04235969111323357,-0.06503494083881378,-0.0633259043097496,-0.06976531445980072,-0.1046174541115761,-0.1486251354217529,-0.1469161063432693,-0.08084353059530258,0.002014221623539925,0.004181035794317722,-0.04101687669754028,-0.02081362344324589,0.0281380657106638,0.05468916893005371,0.05990783497691154,0.06079287081956863,0.05859553813934326,0.031495101749897,0.0155034027993679,-0.00674459058791399,-0.05355998501181602,-0.08236945420503616,-0.06118961051106453,0.02728354744613171,0.1311685591936111,0.1748710572719574,0.1492965519428253,0.1097445636987686,0.0712912380695343,0.04538102447986603,0.08044679462909698,0.1142002642154694,0.1048921197652817,0.0953703448176384,0.05648976191878319,-0.0236518457531929,-0.08505508303642273,-0.08227790147066116,-0.03430280461907387,-0.002044740132987499,0.004882961511611938,-0.002685628831386566,-0.03054902888834476,-0.02606280706822872,0.007263405248522758,-0.00753807183355093,-0.03036591783165932,-0.02951139956712723,-0.04205450788140297,-0.03549302741885185,-0.0395519882440567,-0.07486190646886826,-0.1026032269001007,-0.1141697466373444,-0.09060945361852646,-0.0636005774140358,-0.03402813896536827,-0.009857478551566601,-0.008239997550845146,0.01907406933605671,0.04623554274439812,0.03756828606128693,-0.01168858911842108,-0.09021271765232086,-0.1662648469209671,-0.2544023096561432,-0.317300945520401,-0.3035676181316376,-0.2645039260387421,-0.2580034732818604,-0.2936185896396637,-0.3180028796195984,-0.2682577073574066,-0.2180242389440536,-0.2269661575555801,-0.2209234833717346,-0.1704763919115067,-0.1021454483270645,-0.06927701830863953,-0.0868556797504425,-0.1028473749756813,-0.1051362678408623,-0.09338664263486862,-0.04925687611103058,0.01507614366710186,0.04446546733379364,0.03064058348536491,0.008911404758691788,0.007568590342998505,0.02563554793596268,0.08215583115816116,0.1953794956207275,0.2715536952018738,0.2648396193981171,0.2035889774560928,0.1467940360307693,0.1656849831342697,0.2010254263877869,0.206610307097435,0.1923886835575104,0.1057466343045235,-0.01577807031571865,-0.08536027371883392,-0.1073336005210876,-0.09430219233036041,-0.01577807031571865,0.1026947870850563,0.1228369995951653,0.03250221163034439,-0.06561479717493057,-0.1038239672780037,-0.06524857133626938,-0.03421124815940857,-0.04220709949731827,-0.05957213044166565,-0.03509628772735596,0.003204443491995335,0.003387554548680782,0.02557451091706753,0.0140690328553319,-0.03305154666304588,-0.03628650680184364,-0.0006408886983990669,0.047822505235672,0.05154576152563095,0.02703939937055111,-0.006897183135151863,-0.04074221104383469,-0.04480117186903954,-0.01049836724996567,0.04571672901511192,0.05072176456451416,0.01776177249848843,0.02130191959440708,0.05502487346529961,0.07028412818908691,0.07681509107351303,0.08175908774137497,0.04867702350020409,0.005981627851724625,-0.03021332435309887,-0.07596056908369064,-0.08322397619485855,-0.04467909783124924,0.008087405003607273,0.05429242923855782,0.05139316990971565,0.0712302029132843,0.1531113684177399,0.1861934214830399,0.1848811358213425,0.209082305431366,0.2615131139755249,0.3235572278499603,0.34717857837677,0.3151646554470062,0.2423169612884521,0.1813409775495529,0.1623584777116776,0.1698660254478455,0.1467635184526443,0.1054719686508179,0.07525864243507385,0.03039643540978432,0.00714133121073246,0.02838221378624439,0.039704579859972,0.004242072813212872,-0.001861629076302052,0.02282784506678581,0.01141392253339291,-0.01330607011914253,-0.04461806267499924,-0.07388531416654587,-0.06915494054555893,-0.06033509224653244,-0.06949064880609512,-0.05990783497691154,-0.03070162050426006,-0.009369182400405407,-0.004394665360450745,-0.06295968592166901,-0.1884823143482208,-0.2744529545307159,-0.2453382909297943,-0.1369365453720093,-0.05325479805469513,-0.01629688404500484,0.02508621476590633,0.0281075481325388,-0.01559495832771063,-0.05410931631922722,-0.08563493937253952,-0.1027558222413063,-0.08294931054115295,-0.05859553813934326,-0.08655049651861191,-0.1366313695907593,-0.1485641002655029,-0.09244056791067123,-0.0315561406314373,-0.02163762412965298,-0.04583880305290222,-0.0475478395819664,0.001678518019616604,-0.005066072568297386,-0.0471816174685955,-0.02658162266016006,0.003357036039233208,0.002868739888072014,0.0278634000569582,0.1246070712804794,0.1723685413599014,0.1143223345279694,0.09854426980018616,0.1982482373714447,0.316904217004776,0.3269142806529999,0.2627643644809723,0.1925107538700104,0.1604052931070328,0.1927854269742966,0.2086245268583298,0.2029786109924316,0.2180242389440536,0.1892147660255432,0.1101412996649742,0.07629627734422684,0.1181371510028839,0.1251869201660156,0.02197332680225372,-0.06680501997470856,-0.04397717118263245,0.04190191254019737,0.1027558222413063,0.1164281144738197,0.1058076694607735,0.06653035432100296,0.05490279942750931,0.06579791009426117,0.06009094417095184,0.06585894525051117,0.08334604650735855,0.09884945303201675,0.0871913805603981,0.04489272832870483,0.005645924247801304,-0.0199591051787138,-0.0479750968515873,-0.06860560923814774,-0.05700857564806938,-0.02121036499738693,-0.005249183624982834,-0.02664265967905521,-0.07852412760257721,-0.1703848391771317,-0.2508926689624786,-0.2886135578155518,-0.287240207195282,-0.2347788959741592,-0.1655323952436447,-0.1026642695069313,-0.1039460450410843,-0.1629078090190887,-0.2795800566673279,-0.4140751361846924,-0.4099551439285278,-0.3371379673480988,-0.2683187425136566,-0.1824701726436615,-0.1098055988550186,-0.05352946743369102,-0.01071199681609869,0.01672414317727089,-0.01351969968527555,-0.125949889421463,-0.2388378530740738,-0.3029877543449402,-0.3361613750457764,-0.3274941146373749,-0.3134861290454865,-0.287331759929657,-0.2175054103136063,-0.1305886954069138,-0.0712302029132843,-0.08932767808437347,-0.1907406896352768,-0.2785729467868805,-0.2472609579563141,-0.1547288447618484,-0.08114871382713318,-0.05069124326109886,-0.05456709489226341,-0.05145420879125595,-0.02383495680987835,0.01141392253339291,0.04293954372406006,0.05099643021821976,0.03064058348536491,0.007782219909131527,0.007965330965816975,0.03778191655874252,0.06863612681627274,0.08780175447463989,0.1044953763484955,0.1223792210221291,0.107089452445507,0.08273568004369736,0.0795007199048996,0.05346842855215073,0.02240058593451977,0.03637806326150894,0.08120975643396378,0.1330912262201309,0.1985534280538559,0.2598956227302551,0.2905667424201965,0.256477564573288,0.1640369892120361,0.06131168454885483,-0.02014221623539925,-0.03384502604603767,-0.0001525925472378731,0.02450636401772499,0.0555436871945858,0.08203375339508057,0.06610309332609177,0.01647999510169029,-0.03509628772735596,-0.06973479688167572,-0.0717184990644455,-0.05417035520076752,-0.0236823633313179,0.03707998991012573,0.05844294652342796,0.03738517314195633,0.05893124267458916,0.1242103353142738,0.1845454275608063,0.2198858559131622,0.219458594918251,0.2044129818677902,0.206427201628685,0.2122562378644943,0.193914607167244,0.143528550863266,0.1004974544048309,0.0796533077955246,0.07055879384279251,0.07870723307132721,0.06869716197252274,-0.002075258642435074,-0.0631427988409996,-0.06845301389694214,-0.01889095827937126,0.031434066593647,0.04150517284870148,0.0399182103574276,-0.04107791557908058,-0.1192358136177063,-0.07638783007860184,-0.02044740132987499,-0.02948088012635708,-0.04306161776185036,-0.03405865654349327,-0.0555436871945858,-0.08822900801897049,-0.08514664322137833,-0.0796227902173996,-0.1193273738026619,-0.2060304582118988,-0.2618488073348999,-0.2638935446739197,-0.2600787281990051,-0.2636188864707947,-0.2858058512210846,-0.2887661457061768,-0.2182683795690536,-0.1464583277702332,-0.1352275162935257,-0.1355937421321869,-0.1419415920972824,-0.1091647073626518,-0.05844294652342796,-0.03494369238615036,-0.01525925472378731,0.003997924737632275,0.0399487279355526,0.0394604317843914,0.03378399088978767,0.05041657760739326,0.0198370311409235,-0.03595080599188805,-0.03036591783165932,0.05139316990971565,0.07428205013275146,0.01739555038511753,0.0278634000569582,0.08780175447463989,0.08417005091905594,0.05236976221203804,0.04483168944716454,0.05917539075016975,0.1100497469305992,0.143711656332016,0.1323587745428085,0.1388592123985291,0.1648609936237335,0.1825312077999115,0.2096011191606522,0.2070375680923462,0.1770073622465134,0.2056947499513626,0.2399670332670212,0.2210760861635208,0.1716361045837402,0.1045564115047455,0.08380382508039474,0.1396832168102264,0.1834467649459839,0.1869563907384872,0.1743522435426712,0.09192175418138504,-0.01348918117582798,-0.09384441375732422,-0.146153137087822,-0.1273232251405716,-0.1113620400428772,-0.1368449926376343,-0.1497848480939865,-0.1943418681621552,-0.3035676181316376,-0.3483382761478424,-0.2769860029220581,-0.1765801012516022,-0.06765953451395035,0.01641895808279514,0.04504531994462013,0.02951139956712723,-0.004425183869898319,0.002624591812491417,0.03851436078548431,0.07489242404699326,0.09317301213741302,0.1087374463677406,0.1655018776655197,0.224036380648613,0.2231818586587906,0.1677297353744507,0.09982604533433914,0.05481124296784401,0.03469954431056976,0.02319406718015671,0.03244117647409439,0.03897213563323021,0.01455732900649309,-0.0638142004609108,-0.1352580338716507,-0.1450544744729996,-0.1293679624795914,-0.06973479688167572,0.02670369669795036,0.1161229312419891,0.1623584777116776,0.1419415920972824,0.07986693829298019,0.04257332161068916,0.0557878352701664,0.0876186415553093,0.123538926243782,0.1525620222091675,0.1506698876619339,0.1417584717273712,0.1279946267604828,0.07800531387329102,0.06839197874069214,0.1559190601110458,0.2103030532598495,0.1833857297897339,0.1851863116025925,0.2262337058782578,0.2152470499277115,0.1303140372037888,0.05368205904960632,0.01147495955228806,-0.01907406933605671,-0.04818872734904289,-0.04132206365466118,0.003295999020338058,0.0315561406314373,0.02066103182733059,-0.03772087767720222,-0.05276650190353394,-0.005371257662773132,-0.01629688404500484,-0.1119113713502884,-0.2126529812812805,-0.2625507414340973,-0.2602313160896301,-0.2386547476053238,-0.2605365216732025,-0.2984710335731506,-0.2555620074272156,-0.1171300411224365,0.0316171757876873,0.07840204983949661,0.03799554333090782,0.02075258642435074,-0.005127109587192535,-0.05935849994421005,-0.04336680099368095,0.01687673665583134,0.0394604317843914,-0.02105777151882648,-0.1014740467071533,-0.1426740288734436,-0.1697134375572205,-0.1549424678087234,-0.1225623339414597,-0.1152073740959167,-0.1062959656119347,-0.0789819061756134,-0.01388592179864645,0.09051790088415146,0.1883297264575958,0.2385937124490738,0.2707296907901764,0.3164769411087036,0.3029877543449402,0.2355113327503204,0.1744437962770462,0.1047395244240761,0.03869746997952461,-0.00039674062281847,-0.05478072538971901,-0.1008636727929115,-0.06900235265493393,-0.0238044373691082,-0.0398571752011776,-0.0477614663541317,-0.0004272591322660446,0.04043702408671379,0.06894131004810333,0.1157261878252029,0.1482284069061279,0.1453596651554108,0.1442609876394272,0.1446882486343384,0.1155430749058723,0.06521805375814438,0.0003357036039233208,-0.0395519882440567,-0.004333628341555595,0.04641865193843842,0.04705954343080521,0.05160680040717125,0.1101718172430992,0.1482284069061279,0.1395306289196014,0.1264076679944992,0.1345255970954895,0.1656849831342697,0.1414532959461212,0.04290902614593506,-0.05432294681668282,-0.079317606985569,-0.03460799157619476,0.01196325570344925,0.01724295876920223,-0.009369182400405407,-0.009460737928748131,0.0319528803229332,0.02887050993740559,0.0004577776417136192,0.0475783571600914,0.1226538866758347,0.1111178919672966,0.02853480726480484,-0.01617481000721455,0.0101016266271472,0.047791987657547,0.09414960443973541,0.1507004052400589,0.1375469267368317,0.07705923914909363,0.03250221163034439,0.01651051454246044,0.05368205904960632,0.1115451529622078,0.1173131540417671,0.0715659037232399,0.05206457898020744,0.05890072509646416,0.05902279913425446,0.07293923944234848,0.09143345803022385,0.1192968562245369,0.1189306303858757,0.1026642695069313,0.1155735924839973,0.1015045642852783,0.06634724140167236,0.05740531533956528,0.07269509136676788,0.08810693770647049,0.07330545783042908,0.03604235872626305,0.0238044373691082,0.05148472636938095,0.05090487375855446,0.01388592179864645,-0.03564561903476715,-0.1080050021409988,-0.1507004052400589,-0.1500900238752365,-0.1494796574115753,-0.1468245536088943,-0.1010162681341171,-0.06118961051106453,-0.05072176456451416,-0.04367198795080185,-0.04882961511611938,-0.03668325021862984,-0.02163762412965298,-0.02215643785893917,-0.02856532484292984,-0.03396710008382797,-0.006195257417857647,0.01385540328919888,-0.01873836480081081,-0.04013184085488319,-0.01031525619328022,0.01986755058169365,0.01831110566854477,-0.01110873743891716,-0.05322428047657013,-0.09204382449388504,-0.1476485431194305,-0.1576281040906906,-0.1142307817935944,-0.08661153167486191,-0.09710989892482758,-0.125980406999588,-0.1236610040068626,-0.09567552804946899,-0.05166783556342125,-0.01089510787278414,0.04690694808959961,0.1221350729465485,0.1873226165771484,0.2174138575792313,0.1647083908319473,0.09765923023223877,0.07760857045650482,0.09430219233036041,0.1197851523756981,0.1228064820170403,0.1322672218084335,0.1548203974962234,0.1297036707401276,0.05212561413645744,-0.02511673420667648,-0.1039765626192093,-0.1677602529525757,-0.1499069184064865,-0.08349864184856415,-0.06088442727923393,-0.0313119925558567,0.04953154176473618,0.1128269284963608,0.1211584806442261,0.09836115688085556,0.1145054474473,0.1500289887189865,0.14127017557621,0.1098971515893936,0.04226813465356827,-0.04995879903435707,-0.09692678600549698,-0.1147801131010056,-0.1154210045933723,-0.06106753647327423,0.02319406718015671,0.1054414510726929,0.1291238069534302,0.07388531416654587,0.01986755058169365,-0.05252235382795334,-0.1492965519428253,-0.2188482284545898,-0.2024597972631454,-0.08584856986999512,-0.003814813680946827,-0.001617481000721455,-0.03448591753840446,-0.0636310949921608,-0.03247169405221939,-0.007660145871341228,-0.01849421672523022,-0.03857539594173431,-0.07489242404699326,-0.07415997982025146,-0.06143375858664513,-0.06476027518510818,-0.09418012201786041,-0.128482922911644,-0.1246070712804794,-0.09231849014759064,-0.02398754842579365,0.03415021300315857,0.02902310341596603,-0.002044740132987499,0.0003051850944757462,0.01159703359007835,0.0237739197909832,0.05475020781159401,0.08285775035619736,0.09924619644880295,0.1446272134780884,0.1799371391534805,0.1647999584674835,0.1885433495044708,0.1697439551353455,0.05194250494241714,-0.01663258858025074,0.004638813436031342,0.03527939692139626,0.0008850367739796638,-0.05288857594132423,-0.06155583262443542,-0.05099643021821976,-0.05972472205758095,-0.1200293004512787,-0.2074037939310074,-0.2747276127338409,-0.2831812500953674,-0.239265114068985,-0.1835383176803589,-0.1195104867219925,-0.04962309822440147,0.02542191930115223,0.09085360169410706,0.07318338751792908,-0.02053895778954029,-0.09283730387687683,-0.1237220391631126,-0.07782220095396042,0.01242103334516287,0.03723258152604103,0.03762932121753693,0.02658162266016006,-0.04336680099368095,-0.1008636727929115,-0.08612323552370071,-0.05206457898020744,-0.05420087277889252,-0.06750694662332535,-0.0868556797504425,-0.1065401136875153,-0.1146275252103806,-0.09002960473299026,-0.03073213994503021,-0.006653035059571266,-0.03677480295300484,-0.08352915942668915,-0.0791650116443634,-0.05673390999436378,-0.047822505235672,-0.0714133158326149,-0.123599961400032,-0.128208264708519,-0.1177404075860977,-0.09735404700040817,-0.04373302310705185,-0.006012146361172199,-0.02697836235165596,-0.01513718068599701,0.03744621202349663,0.01739555038511753,-0.03265480697154999,-0.09048738330602646,-0.1537827700376511,-0.1779229044914246,-0.1421857327222824,-0.06131168454885483,0.0196844395250082,0.07254249602556229,0.08453626930713654,0.08926664292812347,0.06112857535481453,-0.002227851189672947,-0.006469924002885818,0.04858546704053879,0.05490279942750931,0.06289865076541901,0.1546067744493484,0.2296212613582611,0.2526017129421234,0.2443311810493469,0.1907712072134018,0.1254921108484268,0.09820856153964996,0.09323404729366302,0.06668294221162796,0.05813775956630707,0.1356242597103119,0.206610307097435,0.1822870522737503,0.1484420299530029,0.1188695952296257,0.08206427097320557,0.0950346365571022,0.09881893545389175,0.06411939114332199,0.04599139466881752,0.02218695729970932,-0.047853022813797,-0.1212500408291817,-0.1948911994695663,-0.2937406599521637,-0.3225501179695129,-0.2858058512210846,-0.2623371183872223,-0.2419507503509521,-0.2501907348632812,-0.2894680500030518,-0.282082587480545,-0.2396008223295212,-0.2269356399774551,-0.2174748927354813,-0.1847895681858063,-0.1746879518032074,-0.2309640794992447,-0.2769554853439331,-0.2478713393211365,-0.2053285390138626,-0.1653492897748947,-0.1130710765719414,-0.06726279854774475,-0.0398266538977623,-0.0278634000569582,-0.07751701772212982,-0.1308633685112,-0.1032136008143425,-0.06872768700122833,-0.04562517255544662,-0.01794488355517387,0.0009460737928748131,-0.009094515815377235,-0.07190161198377609,-0.1677907705307007,-0.2294076383113861,-0.2321848273277283,-0.2278511971235275,-0.1976073533296585,-0.1077303364872932,-0.04400769248604774,-0.04089480265974998,-0.04507583752274513,-0.02945036254823208,-0.002441480755805969,0.04562517255544662,0.08932767808437347,0.1014435291290283,0.09799493104219437,0.05621509626507759,0.06213568523526192,0.1374553740024567,0.176305428147316,0.2129581570625305,0.2651753425598145,0.2595904469490051,0.2164067476987839,0.1692861765623093,0.1102328598499298,0.06552323698997498,0.03582873195409775,0.04351939633488655,0.06195257604122162,0.07712027430534363,0.1135898903012276,0.1036713793873787,0.08145390450954437,0.07242042571306229,0.02069154940545559,-0.006775109097361565,-0.01312295906245708,-0.0394299142062664,-0.05081331729888916,-0.06573686748743057,-0.003112887963652611,0.11456648260355,0.191381573677063,0.2478408217430115,0.2301400750875473,0.141178622841835,0.008392590098083019,-0.0869472324848175,-0.08981597423553467,-0.09231849014759064,-0.0950041189789772,-0.09344767779111862,-0.1188390776515007,-0.09927671402692795,-0.02032532729208469,0.00872829370200634,-0.02899258397519588,-0.09753715991973877,-0.1726432144641876,-0.2012695670127869,-0.1804559528827667,-0.1601306200027466,-0.1398663222789764,-0.08005005121231079,-0.05722220614552498,-0.1103549301624298,-0.1135898903012276,-0.07721182703971863,-0.09228797256946564,-0.05636768788099289,0.04702902212738991,0.1199072226881981,0.1810968369245529,0.1786858737468719,0.08206427097320557,-0.01120029296725988,-0.04354991391301155,-0.05642872303724289,-0.1179540380835533,-0.1694387644529343,-0.1361430734395981,-0.09775078296661377,-0.09811700880527496,-0.1179235205054283,-0.1606189161539078,-0.193639948964119,-0.2164983004331589,-0.2264168262481689,-0.2226325273513794,-0.2257759273052216,-0.2364268898963928,-0.2144535630941391,-0.1499679535627365,-0.1026032269001007,-0.04425184056162834,0.0197149571031332,0.04431287571787834,0.09082308411598206,0.1341593712568283,0.05386516824364662,-0.07712027430534363,-0.09472945332527161,-0.02386547438800335,0.03918576613068581,0.06476027518510818,0.08322397619485855,0.0874355286359787,0.03003021329641342,-0.09121982753276825,-0.1885128319263458,-0.1996826082468033,-0.1778313517570496,-0.1416058838367462,-0.1114230751991272,-0.07882931083440781,-0.0320444367825985,-0.02575762197375298,-0.03320413827896118,-0.03756828606128693,-0.09375286102294922,-0.1102633774280548,-0.04248176515102386,-0.0241706594824791,-0.07309182733297348,-0.1091341897845268,-0.1065706387162209,-0.08581805229187012,0.006958220154047012,0.1415753662586212,0.1987975686788559,0.186315506696701,0.1701101660728455,0.2323068976402283,0.3392742574214935,0.4145328998565674,0.4192022383213043,0.2938932478427887,0.1210058927536011,0.03277688100934029,-0.01150547806173563,-0.08310189843177795,-0.1065401136875153,-0.04821924492716789,-0.01565599627792835,-0.0635700523853302,-0.112033449113369,-0.07473982870578766,0.027405621483922,0.1223792210221291,0.1716361045837402,0.1985229104757309,0.2081362307071686,0.1921750605106354,0.1546067744493484,0.07373271882534027,-0.004669331945478916,-0.03372295200824738,-0.01242103334516287,0.02499466016888618,0.07089449465274811,0.1088595241308212,0.0949736014008522,0.007293923757970333,-0.1163670793175697,-0.191625714302063,-0.2501296997070312,-0.2624897062778473,-0.2370677888393402,-0.2383190393447876,-0.23905149102211,-0.2213202267885208,-0.1875362396240234,-0.1468245536088943,-0.1106601133942604,-0.1047395244240761,-0.1473433673381805,-0.2036805301904678,-0.2132023125886917,-0.2211371213197708,-0.2627033293247223,-0.2936796247959137,-0.2497634887695312,-0.1164586320519447,0.03839228674769402,0.1579638123512268,0.2373424470424652,0.3056428730487823,0.3254188597202301,0.2303537130355835,0.08175908774137497,0.003784295171499252,0.02862636186182499,0.1025421917438507,0.1673635095357895,0.1710562407970428,0.07565538585186005,-0.06784264743328094,-0.1807000935077667,-0.2361522316932678,-0.1992248296737671,-0.1078524142503738,-0.07889034599065781,-0.1038239672780037,-0.0952177494764328,-0.1127048581838608,-0.1749015748500824,-0.194006159901619,-0.1870479434728622,-0.1724906116724014,-0.1389812976121902,-0.1274452954530716,-0.1518601030111313,-0.1822565346956253,-0.224341556429863,-0.2486953288316727,-0.2178106009960175,-0.1963255703449249,-0.2145451158285141,-0.2275765240192413,-0.2174138575792313,-0.1291238069534302,0.004516739398241043,0.0710470899939537,0.03534043580293655,-0.04260383918881416,-0.08023316413164139,-0.08612323552370071,-0.05114902183413506,-0.001556443981826305,0.05899227783083916,0.1106601133942604,0.1115756705403328,0.09881893545389175,0.06677450239658356,0.02630695514380932,0.00476088747382164,-0.04342783987522125,-0.1165501847863197,-0.1029999703168869,-0.008789330720901489,0.06466872245073318,0.06176946312189102,-0.01525925472378731,-0.09823907911777496,-0.07303079217672348,0.06491287052631378,0.2113711982965469,0.2331003695726395,0.1184423342347145,0.05444502085447311,0.08645893633365631,0.1804864704608917,0.2811059951782227,0.2791222929954529,0.1607104688882828,0.05804620683193207,0.02206488326191902,-0.03244117647409439,-0.02453688159584999,0.04019287601113319,0.02395703084766865,0.02160710468888283,0.1204260364174843,0.2099978625774384,0.236762598156929,0.2353587448596954,0.2262642234563828,0.2318796366453171,0.3051851093769073,0.3663441836833954,0.3599353134632111,0.3148594498634338,0.2617877721786499,0.2863856852054596,0.3591418266296387,0.4457838535308838,0.4792931973934174,0.491439551115036,0.4925382137298584,0.3320719003677368,0.1354106217622757,0.04882961511611938,0.01834162510931492,-0.03021332435309887,-0.11444441229105,-0.1423383355140686,-0.113223671913147,-0.08227790147066116,-0.04144413769245148,-0.0238959938287735,-0.003051850944757462,-0.008270516060292721,-0.0475173182785511,-0.03610339760780334,-0.0005493331700563431,0.005249183624982834,-0.005645924247801304,-0.001007110811769962,-0.02905362099409103,-0.1181676685810089,-0.2153996378183365,-0.2605060040950775,-0.2575151920318604,-0.236915186047554,-0.2244331240653992,-0.2269051223993301,-0.2328562289476395,-0.2865382730960846,-0.3264259696006775,-0.2790612578392029,-0.2337412685155869,-0.2776573896408081,-0.3584704101085663,-0.3306375443935394,-0.1977599412202835,-0.06988738477230072,0.01028473768383265,0.03717154636979103,0.08539079129695892,0.08899197727441788,-0.01937925443053246,-0.1300698816776276,-0.2372508943080902,-0.2850733995437622,-0.2682271897792816,-0.2800683677196503,-0.2604144513607025,-0.1568956524133682,-0.08661153167486191,-0.1105075255036354,-0.1380657404661179,-0.1932126879692078,-0.1968443840742111,-0.09164708107709885,-0.04907376319169998,-0.1212195232510567,-0.2667317688465118,-0.3455610871315002,-0.3402508497238159,-0.3270668685436249,-0.2960905730724335,-0.2979522049427032,-0.3148594498634338,-0.2660603523254395,-0.1996520906686783,-0.1849116533994675,-0.1543626189231873,-0.1316568553447723,-0.1289712190628052,-0.05984679609537125,0.1148716732859612,0.3142796158790588,0.4055604636669159,0.426068902015686,0.3588061034679413,0.1703848391771317,0.0557878352701664,0.03677480295300484,0.01379436627030373,0.04232917353510857,0.05990783497691154,0.1202734485268593,0.3281960487365723,0.4811243116855621,0.425397515296936,0.2763451039791107,0.1317178905010223,-0.002990813925862312,-0.03817865625023842,0.08047731220722198,0.2097842395305634,0.2583697140216827,0.2595599293708801,0.1641590595245361,0.02291940152645111,-0.02603228949010372,-0.01513718068599701,-0.004882961511611938,0.031434066593647,0.05624561384320259,0.01306192204356194,0.009643848985433578,0.110843226313591,0.1822565346956253,0.1834772825241089,0.1724906116724014,0.1512192189693451,0.09695730358362198,0.01107821892946959,-0.09634693711996078,-0.1296121031045914,0.01629688404500484,0.1940977275371552,0.3161412477493286,0.4207281768321991,0.4568620920181274,0.4526505470275879,0.4764549732208252,0.5284890532493591,0.5676748156547546,0.5581225156784058,0.4990081489086151,0.4335154294967651,0.4224982559680939,0.4929044544696808,0.5431379079818726,0.5136570334434509,0.4296090602874756,0.3067415356636047,0.2141178697347641,0.1899472028017044,0.1990112066268921,0.1216162592172623,0.0552079826593399,0.1068147867918015,0.14120914041996,0.08059938251972198,-0.01681569963693619,-0.03857539594173431,0.002197332680225372,0.06781212985515594,0.07419049739837646,0.007415997795760632,-0.04293954372406006,-0.05197302252054214,-0.08603167533874512,-0.1948911994695663,-0.269264817237854,-0.3008819818496704,-0.3385113179683685,-0.3491927981376648,-0.3129978477954865,-0.269508957862854,-0.223914310336113,-0.1618091315031052,-0.08917508274316788,-0.06036561354994774,-0.05740531533956528,0.02029480971395969,0.1066316738724709,0.1312601119279861,0.1093783378601074,0.1113010048866272,0.1708121001720428,0.2249214202165604,0.2023682296276093,0.1509445458650589,0.1790520995855331,0.2634357810020447,0.269600510597229,0.1446577310562134,0.01312295906245708,-0.04654072597622871,-0.110782191157341,-0.1692251414060593,-0.1295815855264664,-0.1233252957463264,-0.1509445458650589,-0.09082308411598206,-0.09598071128129959,-0.1747184693813324,-0.2575457096099854,-0.3679311573505402,-0.3237098157405853,-0.1278115212917328,-0.07019257545471191,-0.1201818883419037,-0.1136509329080582,-0.1046784892678261,-0.1051667854189873,-0.1025116741657257,-0.1578417271375656,-0.2026734203100204,-0.1491744816303253,-0.08899197727441788,0.0001831110566854477,0.09805597364902496,0.1243629232048988,0.1597033590078354,0.1124912276864052,-0.047883540391922,-0.219428077340126,-0.3361613750457764,-0.299813836812973,-0.09628589451313019,0.09881893545389175,0.1351664811372757,0.08438368141651154,0.006225775927305222,-0.06207465007901192,-0.09479048848152161,-0.123538926243782,-0.1125827804207802,0.004669331945478916,0.1439252942800522,0.158848837018013,0.1002838239073753,0.05713064968585968,0.0631122812628746,0.1010773032903671,0.1276284009218216,0.1345561146736145,0.1153904870152473,0.1686147600412369,0.2679525017738342,0.269234299659729,0.1389202624559402,-0.01544236578047276,-0.0796533077955246,-0.04037598893046379,0.07455671578645706,0.1196630746126175,0.079317606985569,0.03616443276405334,0.05142368748784065,0.1843012720346451,0.3020111620426178,0.3006988763809204,0.2953581213951111,0.3269142806529999,0.2902005016803741,0.2162236422300339,0.1415448486804962,0.04019287601113319,-0.01593066193163395,-0.02475051209330559,-0.04806665331125259,-0.06109805777668953,-0.0872829407453537,-0.1543321013450623,-0.2263557910919189,-0.3101901412010193,-0.3558152914047241,-0.3512985706329346,-0.3678396046161652,-0.3544419705867767,-0.2736289501190186,-0.1979430466890335,-0.1420941799879074,-0.1092867851257324,-0.1066011562943459,-0.08560442179441452,-0.01553392130881548,0.06509598344564438,0.0796838253736496,-0.0001831110566854477,-0.1019013002514839,-0.1134373024106026,-0.08798485994338989,-0.06128116697072983,0.01440473645925522,0.04422131925821304,0.02160710468888283,-0.01367229223251343,-0.09967344999313354,-0.1731620281934738,-0.1829584687948227,-0.1479232162237167,-0.0394604317843914,0.04553361609578133,0.04162724688649178,0.03805658221244812,0.02923673205077648,0.03317362070083618,0.03698843345046043,-0.02566606737673283,-0.1140476688742638,-0.1414227783679962,-0.1025727093219757,-0.06530961394309998,-0.01333658862859011,0.04596087709069252,0.05105746537446976,0.03564561903476715,0.08188115805387497,0.1756035089492798,0.2305673360824585,0.2166203856468201,0.1481978893280029,0.08096560835838318,0.031464584171772,-0.003082369454205036,-0.0139469588175416,-0.03103732503950596,-0.02261421643197536,0.05902279913425446,0.128238782286644,0.1136509329080582,0.09350871294736862,0.04333628341555595,-0.02499466016888618,-0.02728354744613171,0.02069154940545559,0.09256263822317123,0.1217688545584679,0.1222876682877541,0.1307412981987,0.09060945361852646,-0.02591021545231342,-0.1334879547357559,-0.1724906116724014,-0.156437873840332,-0.07284767925739288,0.02362132631242275,0.07391583174467087,0.07852412760257721,0.1098971515893936,0.1523178815841675,0.1199987828731537,0.06070131435990334,0.05288857594132423,0.07736442238092422,0.03540147095918655,-0.02780236303806305,-0.005981627851724625,0.07531968504190445,0.17374187707901,0.2735679149627686,0.3018890917301178,0.2706686556339264,0.2277291119098663,0.1395916640758514,0.0949430838227272,0.1155125573277473,0.09009063988924026,0.07058931142091751,0.07593005150556564,0.1214026287198067,0.2272102981805801,0.3032929599285126,0.352397233247757,0.3846858143806458,0.3715933859348297,0.3108310103416443,0.2046266049146652,0.07330545783042908,-0.04882961511611938,-0.113223671913147,-0.1170690059661865,-0.1673024743795395,-0.2486037760972977,-0.2579119205474854,-0.2353587448596954,-0.2106082290410995,-0.1783196479082108,-0.17386394739151,-0.1813104599714279,-0.1702322512865067,-0.1406292915344238,-0.08981597423553467,-0.05365154147148132,-0.07226783037185669,-0.0954008623957634,-0.05481124296784401,0.03424176946282387,0.09448530524969101,0.07675404846668243,0.03851436078548431,0.1030610054731369,0.2290414124727249,0.2589495480060577,0.2886745929718018,0.4042176604270935,0.4775231182575226,0.4694052040576935,0.4210333526134491,0.3755913078784943,0.3766899704933167,0.3896298110485077,0.3665578067302704,0.3620105683803558,0.3606982529163361,0.2949613928794861,0.2486953288316727,0.2220221608877182,0.1942197978496552,0.156071662902832,0.09930723160505295,0.1094698905944824,0.14120914041996,0.1590624749660492,0.1398358047008514,0.04812768846750259,-0.03524887934327126,-0.08172857016324997,-0.09625537693500519,-0.07638783007860184,-0.08197271823883057,-0.09231849014759064,-0.1441694349050522,-0.282082587480545,-0.400799572467804,-0.4713583886623383,-0.5189062356948853,-0.5620288848876953,-0.6060975790023804,-0.5852839946746826,-0.5370647311210632,-0.5695364475250244,-0.6053651571273804,-0.6129337549209595,-0.6196478009223938,-0.5659962892532349,-0.4918057918548584,-0.4531083106994629,-0.4122745394706726,-0.2890102863311768,-0.1355632245540619,-0.04934842884540558,0.02636799216270447,0.09018219262361526,0.1319315135478973,0.2106082290410995,0.2707296907901764,0.2665486633777618,0.2790307402610779,0.3029877543449402,0.282326728105545,0.2247993350028992,0.1457258760929108,0.0]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>ar15</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ar15</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ar15_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ar15_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>baretta_9mm</source_block_id><sink_block_id>blocks_threshold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>ar15</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>ar15_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>baretta_9mm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>desert_eagle_357</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>generic_gunshot</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>luger_9mm</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>pistol_38</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>sig_sauer_308</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>desert_eagle_357</source_block_id><sink_block_id>blocks_threshold_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>generic_gunshot</source_block_id><sink_block_id>blocks_threshold_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>luger_9mm</source_block_id><sink_block_id>blocks_threshold_ff_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pistol_38</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sig_sauer_308</source_block_id><sink_block_id>blocks_threshold_ff_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
