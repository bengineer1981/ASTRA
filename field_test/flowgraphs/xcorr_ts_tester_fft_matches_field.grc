<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xcorr_tester</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_mic_offset</value></param>
<param><key>value</key><value>1024*10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d1</value></param>
<param><key>value</key><value>-64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d2</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d3</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mic_distance</value></param>
<param><key>value</key><value>.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>astra_xcorr_ts_ff</key>
<param><key>id</key><value>astra_xcorr_ts_ff_0</value></param>
<param><key>ip_address</key><value>10.0.0.2</value></param>
<param><key>center_mic_offset</key><value>center_mic_offset</value></param>
<param><key>mic_distance</key><value>mic_distance</value></param>
<param><key>node_number</key><value>1</value></param>
<param><key>port_num</key><value>5555</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_window</key><value>15000</value></param>
<param><key>test_number</key><value>school.testing.10.08.16</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>device_name</key><value>plughw:0,0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>plughw:2,0</value></param>
<param><key>num_outputs</key><value>4</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>d2+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>d3+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_2</value></param>
<param><key>delay</key><value>d1+center_mic_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/ben/Desktop/senior_design/field_test/audio_recordings/AK47.50m</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>threshold</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>threshold</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0.5253016948699951,0.4734492301940918,0.5113112926483154,0.5735743045806885,0.6195724010467529,0.6624305248260498,0.7190859317779541,0.6990087032318115,0.5683779716491699,0.4158782958984375,0.31394362449646,0.2423858642578125,0.1710319519042969,0.148015022277832,0.1331984996795654,0.08835196495056152,0.05057215690612793,0.04767894744873047,0.05631208419799805,0.07057428359985352,0.04726052284240723,-0.01195907592773438,-0.1281988620758057,-0.3188216686248779,-0.5103099346160889,-0.6066656112670898,-0.63179612159729,-0.6866347789764404,-0.7369852066040039,-0.7117509841918945,-0.6778228282928467,-0.6898391246795654,-0.7192182540893555,-0.7167112827301025,-0.6931507587432861,-0.6474709510803223,-0.5971276760101318,-0.6732273101806641,-0.8412837982177734,-0.8871102333068848,-0.8505570888519287,-0.8649086952209473,-0.8974099159240723,-0.8669936656951904,-0.7913875579833984,-0.7178628444671631,-0.6359302997589111,-0.56496262550354,-0.504305362701416,-0.4158854484558105,-0.2807486057281494,-0.1623594760894775,-0.07570624351501465,0.006312131881713867,0.1016843318939209,0.2220654487609863,0.3162610530853271,0.3199517726898193,0.2873361110687256,0.3126204013824463,0.3524672985076904,0.3640079498291016,0.3533649444580078,0.3115403652191162,0.2641189098358154,0.300976037979126,0.4199552536010742,0.524822473526001,0.6049633026123047,0.6511151790618896,0.5674874782562256,0.327308177947998,0.09755730628967285,-0.04764318466186523,-0.131828784942627,-0.1746582984924316,-0.1746046543121338,-0.2040731906890869,-0.2665543556213379,-0.2901005744934082,-0.2707314491271973,-0.3026354312896729,-0.4184496402740479,-0.5040657520294189,-0.4857730865478516,-0.3776764869689941,-0.2812743186950684,-0.2370035648345947,-0.2279984951019287,-0.235830545425415,-0.2560436725616455,-0.2476787567138672,-0.1362061500549316,-0.01359343528747559,0.02373933792114258,0.09890198707580566,0.2804875373840332,0.4295969009399414,0.4514336585998535,0.4591584205627441,0.5655062198638916,0.6571304798126221,0.5993807315826416,0.4702270030975342,0.3566300868988037,0.2820682525634766,0.2364349365234375,0.2645230293273926,0.3852188587188721,0.4616403579711914,0.394742488861084,0.3153491020202637,0.3609609603881836,0.4377973079681396,0.4734277725219727,0.4683780670166016,0.4010939598083496,0.2911627292633057,0.2495133876800537,0.2491164207458496,0.1828587055206299,0.06454825401306152,-0.01690506935119629,-0.07414340972900391,-0.1411449909210205,-0.1639044284820557,-0.1281344890594482,-0.06897211074829102,0.009298324584960938,0.1613044738769531,0.3601706027984619,0.4992806911468506,0.5082607269287109,0.4290676116943359,0.3456830978393555,0.2622699737548828,0.1625239849090576,0.05926609039306641,-0.05405545234680176,-0.1706922054290771,-0.2207851409912109,-0.1460301876068115,0.02128243446350098,0.1625955104827881,0.2564370632171631,0.3112006187438965,0.3940951824188232,0.4974532127380371,0.6095802783966064,0.7116186618804932,0.837407112121582,0.9174656867980957,0.8596014976501465,0.7189035415649414,0.6716358661651611,0.6962943077087402,0.641019344329834,0.550997257232666,0.5241572856903076,0.5268466472625732,0.4886448383331299,0.399702787399292,0.2992630004882812,0.1912128925323486,0.1370108127593994,0.1923751831054688,0.3189826011657715,0.4131245613098145,0.4188859462738037,0.3421962261199951,0.2743291854858398,0.3267860412597656,0.4837346076965332,0.6371212005615234,0.6714534759521484,0.6007933616638184,0.5331051349639893,0.4397821426391602,0.3068411350250244,0.2219009399414062,0.2633571624755859,0.3463268280029297,0.3750407695770264,0.3316497802734375,0.2424037456512451,0.0690150260925293,-0.1675736904144287,-0.3721332550048828,-0.4851257801055908,-0.4561185836791992,-0.3383052349090576,-0.2295148372650146,-0.1165544986724854,-0.01703739166259766,-0.01386523246765137,-0.1668477058410645,-0.3741145133972168,-0.5385839939117432,-0.6992018222808838,-0.8092331886291504,-0.7860982418060303,-0.6729769706726074,-0.6679129600524902,-0.8321142196655273,-1.042417287826538,-1.142435073852539,-1.16631031036377,-1.136219501495361,-0.9919631481170654,-0.7431221008300781,-0.5109071731567383,-0.381925106048584,-0.365595817565918,-0.4195332527160645,-0.5098915100097656,-0.5972528457641602,-0.6404507160186768,-0.6640040874481201,-0.6585431098937988,-0.6779658794403076,-0.7747113704681396,-0.8906865119934082,-0.9842383861541748,-1.045732498168945,-0.9995341300964355,-0.8513867855072021,-0.7741427421569824,-0.777665376663208,-0.7055032253265381,-0.608525276184082,-0.6100559234619141,-0.6420314311981201,-0.5284059047698975,-0.3787779808044434,-0.3791534900665283,-0.5740928649902344,-0.7899177074432373,-0.9147977828979492,-0.9783339500427246,-1.024339199066162,-1.013309955596924,-0.9395205974578857,-0.8284091949462891,-0.6671619415283203,-0.5075633525848389,-0.4042267799377441,-0.3951179981231689,-0.4035723209381104,-0.338737964630127,-0.2299082279205322,-0.1620197296142578,-0.1663434505462646,-0.2282989025115967,-0.3351831436157227,-0.3691613674163818,-0.2565443515777588,-0.08957505226135254,-0.009523630142211914,-0.05570411682128906,-0.1391208171844482,-0.1447892189025879,-0.0189971923828125,0.1847827434539795,0.3660750389099121,0.4526710510253906,0.4556214809417725,0.4152023792266846,0.3943634033203125,0.4788386821746826,0.6177985668182373,0.7185101509094238,0.8145618438720703,0.9282088279724121,0.989992618560791,0.9727156162261963,0.9767675399780273,1.076524257659912,1.213123798370361,1.363091468811035,1.461517810821533,1.380354166030884,1.15082859992981,0.9829044342041016,0.9731161594390869,1.011157035827637,1.013935804367065,1.004612445831299,0.9938263893127441,0.9338164329528809,0.8472955226898193,0.7933080196380615,0.7779407501220703,0.8124947547912598,0.9037327766418457,0.9854328632354736,0.959923267364502,0.8294355869293213,0.682990550994873,0.5599129199981689,0.4527819156646729,0.4104137420654297,0.4558110237121582,0.5297970771789551,0.5708563327789307,0.6658315658569336,0.8318638801574707,0.9824681282043457,1.012637615203857,0.9366095066070557,0.8366489410400391,0.7493698596954346,0.7269322872161865,0.7178020477294922,0.6432723999023438,0.5099809169769287,0.4458582401275635,0.5268001556396484,0.6585609912872314,0.6723225116729736,0.5379080772399902,0.3907763957977295,0.3249549865722656,0.2995133399963379,0.2493596076965332,0.1474606990814209,0.07309556007385254,0.08177876472473145,0.09047985076904297,0.1162612438201904,0.2445566654205322,0.3631961345672607,0.3394997119903564,0.2927899360656738,0.2888059616088867,0.285261869430542,0.2921783924102783,0.2486515045166016,0.1516270637512207,0.06675839424133301,0.027008056640625,-0.05540013313293457,-0.2110075950622559,-0.3417277336120605,-0.356522798538208,-0.3085970878601074,-0.2984583377838135,-0.35805344581604,-0.4604744911193848,-0.5573809146881104,-0.5768716335296631,-0.5821430683135986,-0.676267147064209,-0.8845603466033936,-1.111228466033936,-1.262708902359009,-1.370687484741211,-1.449029445648193,-1.408041715621948,-1.276760101318359,-1.243243217468262,-1.328541040420532,-1.357094049453735,-1.268638372421265,-1.178083419799805,-1.11644983291626,-1.159762144088745,-1.368330717086792,-1.613856554031372,-1.723015308380127,-1.696511507034302,-1.644272804260254,-1.564593315124512,-1.434556245803833,-1.280354261398315,-1.220033168792725,-1.30345344543457,-1.396104097366333,-1.31487250328064,-1.104569435119629,-0.9584641456604004,-0.910191535949707,-0.9496700763702393,-1.070530414581299,-1.237474679946899,-1.338132619857788,-1.34965181350708,-1.312158107757568,-1.211385726928711,-1.042524576187134,-0.8309841156005859,-0.647660493850708,-0.5141258239746094,-0.4464411735534668,-0.4760527610778809,-0.5886411666870117,-0.7024812698364258,-0.7837522029876709,-0.8791708946228027,-0.9676623344421387,-0.9368133544921875,-0.7683062553405762,-0.6149947643280029,-0.6085038185119629,-0.686180591583252,-0.7344567775726318,-0.7457756996154785,-0.7117331027984619,-0.6374895572662354,-0.5580604076385498,-0.461193323135376,-0.312269926071167,-0.149770975112915,-0.03914594650268555,0.0273585319519043,0.135265588760376,0.2527284622192383,0.2481794357299805,0.1498425006866455,0.1271796226501465,0.1578712463378906,0.11802077293396,0.1328766345977783,0.3120517730712891,0.4786777496337891,0.4345822334289551,0.3621196746826172,0.4793071746826172,0.7301652431488037,0.9347140789031982,1.074661016464233,1.146987676620483,1.11178994178772,0.9552633762359619,0.7859373092651367,0.7220935821533203,0.6917881965637207,0.5904829502105713,0.5550813674926758,0.7626736164093018,1.017054319381714,1.077146530151367,1.131162643432617,1.301822662353516,1.355388164520264,1.177464723587036,0.9633243083953857,0.8759665489196777,0.8880615234375,0.9303581714630127,0.9268784523010254,0.9441161155700684,1.045829057693481,1.184284687042236,1.301904916763306,1.345639228820801,1.22380256652832,0.926506519317627,0.717766284942627,0.7594335079193115,0.8975529670715332,0.9552597999572754,0.9777617454528809,1.036566495895386,1.113159656524658,1.115877628326416,0.9563577175140381,0.6732344627380371,0.439528226852417,0.3606033325195312,0.2587223052978516,0.08154988288879395,-0.01035332679748535,0.05012154579162598,0.09276509284973145,0.06433367729187012,0.09245395660400391,0.1238429546356201,0.007703304290771484,-0.2361202239990234,-0.397331714630127,-0.3813350200653076,-0.2876043319702148,-0.2021598815917969,-0.09552597999572754,0.04269003868103027,0.1378762722015381,0.1039588451385498,-0.04317283630371094,-0.1963019371032715,-0.3364455699920654,-0.4619550704956055,-0.5830979347229004,-0.6858837604522705,-0.7173764705657959,-0.6226658821105957,-0.4798901081085205,-0.4312634468078613,-0.4943275451660156,-0.5800545215606689,-0.6313061714172363,-0.6676661968231201,-0.6928539276123047,-0.7415878772735596,-0.7962405681610107,-0.804283618927002,-0.6942558288574219,-0.5920100212097168,-0.620959997177124,-0.7739531993865967,-0.8998310565948486,-0.8882224559783936,-0.8351147174835205,-0.8297252655029297,-0.8669364452362061,-0.8751761913299561,-0.8491551876068115,-0.8053457736968994,-0.781320333480835,-0.7948422431945801,-0.7913017272949219,-0.7834696769714355,-0.8089148998260498,-0.8953285217285156,-1.029846668243408,-1.128759384155273,-1.18444561958313,-1.264643669128418,-1.333605051040649,-1.294312477111816,-1.174145936965942,-1.075133085250854,-0.9864449501037598,-0.8699977397918701,-0.8403146266937256,-0.8914732933044434,-0.8752119541168213,-0.7327365875244141,-0.5717718601226807,-0.485079288482666,-0.5052673816680908,-0.5692577362060547,-0.6326580047607422,-0.650714635848999,-0.6220114231109619,-0.6109428405761719,-0.6677091121673584,-0.7151412963867188,-0.6576275825500488,-0.53183913230896,-0.4753768444061279,-0.4351651668548584,-0.2771186828613281,-0.05469918251037598,0.05540370941162109,0.02368569374084473,-0.0661468505859375,-0.1200056076049805,-0.1161575317382812,-0.09429574012756348,-0.08048772811889648,-0.08649945259094238,-0.1179850101470947,-0.05806803703308105,0.1753914356231689,0.4211926460266113,0.5506432056427002,0.6378507614135742,0.7622015476226807,0.8401072025299072,0.827186107635498,0.7854795455932617,0.7457506656646729,0.7122981548309326,0.7341456413269043,0.805889368057251,0.8488333225250244,0.8317816257476807,0.7909190654754639,0.7840847969055176,0.8288168907165527,0.8793175220489502,0.8484649658203125,0.7660746574401855,0.747295618057251,0.7675695419311523,0.6891703605651855,0.5109751224517822,0.340808629989624,0.2201271057128906,0.1866996288299561,0.2060902118682861,0.1915848255157471,0.1046311855316162,0.02007365226745605,-0.01236677169799805,-0.01899003982543945,0.0251305103302002,0.1478004455566406,0.1868963241577148,0.04584431648254395,-0.1493239402770996,-0.2309954166412354,-0.2725660800933838,-0.34798264503479,-0.4399323463439941,-0.521700382232666,-0.6428110599517822,-0.7137715816497803,-0.6670832633972168,-0.5513262748718262,-0.4190361499786377,-0.2874577045440674,-0.1465559005737305,-0.04635214805603027,-0.06513833999633789,-0.2036690711975098,-0.3506505489349365,-0.4103779792785645,-0.4241287708282471,-0.3938412666320801,-0.2444171905517578,-0.001502037048339844,0.1852834224700928,0.2394461631774902,0.2249550819396973,0.2551138401031494,0.3397321701049805,0.3796577453613281,0.382150411605835,0.425952672958374,0.472569465637207,0.4472994804382324,0.3827798366546631,0.3070592880249023,0.1717150211334229,0.0291287899017334,-0.0331270694732666,0.03073453903198242,0.1394033432006836,0.2256453037261963,0.2610790729522705,0.2347719669342041,0.1414096355438232,0.0191187858581543,-0.0491631031036377,-0.02668619155883789,0.05410552024841309,0.1672518253326416,0.2671623229980469,0.2490878105163574,0.0726020336151123,-0.1841139793395996,-0.4093873500823975,-0.5491554737091064,-0.5606961250305176,-0.5194473266601562,-0.5180740356445312,-0.5137360095977783,-0.4161322116851807,-0.3533613681793213,-0.4389381408691406,-0.5899214744567871,-0.6911122798919678,-0.7349824905395508,-0.7666289806365967,-0.788733959197998,-0.8240962028503418,-0.8757984638214111,-0.9591794013977051,-1.027164459228516,-1.031337976455688,-0.955270528793335,-0.8450174331665039,-0.748676061630249,-0.6928360462188721,-0.6644546985626221,-0.6890201568603516,-0.7812952995300293,-0.9225833415985107,-1.036745309829712,-1.104934215545654,-1.105771064758301,-1.026356220245361,-0.9075593948364258,-0.8064365386962891,-0.7476389408111572,-0.697706937789917,-0.5920493602752686,-0.3981828689575195,-0.1465344429016113,0.09522557258605957,0.2685964107513428,0.4002892971038818,0.5288815498352051,0.593111515045166,0.5627346038818359,0.5130064487457275,0.5142045021057129,0.5549383163452148,0.648043155670166,0.7541012763977051,0.8253657817840576,0.8754909038543701,0.9547090530395508,1.014844179153442,1.020920276641846,0.9349715709686279,0.7620012760162354,0.5727803707122803,0.4350900650024414,0.3438019752502441,0.2446568012237549,0.178910493850708,0.1439273357391357,0.1027679443359375,0.0265967845916748,-0.08200407028198242,-0.1655459403991699,-0.1311922073364258,0.02975821495056152,0.1473355293273926,0.1489377021789551,0.1629853248596191,0.2694690227508545,0.3032684326171875,0.2970170974731445,0.3704738616943359,0.3999888896942139,0.2775192260742188,0.123131275177002,0.1003468036651611,0.1598954200744629,0.2436089515686035,0.364304780960083,0.5295252799987793,0.6514906883239746,0.6756198406219482,0.6100702285766602,0.5361342430114746,0.5348289012908936,0.580676794052124,0.6302618980407715,0.6636106967926025,0.6744003295898438,0.6336092948913574,0.5298721790313721,0.4733312129974365,0.483630895614624,0.4725480079650879,0.4467880725860596,0.4582321643829346,0.4379045963287354,0.3270542621612549,0.2169585227966309,0.1723766326904297,0.1425433158874512,0.1134967803955078,0.1626169681549072,0.269089937210083,0.3226304054260254,0.2670550346374512,0.1504504680633545,0.02867460250854492,-0.03139257431030273,0.005546808242797852,0.07807016372680664,0.126950740814209,0.1831376552581787,0.3572380542755127,0.6096231937408447,0.7699441909790039,0.700070858001709,0.4444563388824463,0.1876723766326904,0.03709673881530762,-0.07465481758117676,-0.1641762256622314,-0.1092946529388428,0.01474499702453613,0.01629352569580078,-0.1378476619720459,-0.2765750885009766,-0.3426074981689453,-0.4058468341827393,-0.4627025127410889,-0.4525065422058105,-0.4018378257751465,-0.4658496379852295,-0.7321500778198242,-1.052641868591309,-1.279324293136597,-1.423577070236206,-1.434627771377563,-1.246472597122192,-0.9903967380523682,-0.8952426910400391,-0.9608423709869385,-1.115058660507202,-1.321145296096802,-1.464124917984009,-1.445589065551758,-1.346604824066162,-1.20840311050415,-1.010273694992065,-0.8871495723724365,-1.045389175415039,-1.343979835510254,-1.487245559692383,-1.443264484405518,-1.385858058929443,-1.345031261444092,-1.215838193893433,-1.009272336959839,-0.8766603469848633,-0.8494341373443604,-0.8822286128997803,-0.8819031715393066,-0.854794979095459,-0.7722187042236328,-0.5534577369689941,-0.2746403217315674,-0.08717894554138184,0.005925893783569336,0.01325726509094238,-0.1229667663574219,-0.3352117538452148,-0.4601311683654785,-0.4866814613342285,-0.5121731758117676,-0.5256950855255127,-0.4998564720153809,-0.3722298145294189,-0.1587545871734619,0.08747220039367676,0.2398538589477539,0.2676737308502197,0.2646660804748535,0.2413272857666016,0.1434516906738281,0.01842141151428223,-0.06405472755432129,-0.1079249382019043,-0.1424682140350342,-0.1596951484680176,-0.1009654998779297,0.1187002658843994,0.3318536281585693,0.3621268272399902,0.3370964527130127,0.3502392768859863,0.2941346168518066,0.1565587520599365,0.1363027095794678,0.2655351161956787,0.3458583354949951,0.3741574287414551,0.5031359195709229,0.6498134136199951,0.6485080718994141,0.5603742599487305,0.5150341987609863,0.5044591426849365,0.4441380500793457,0.4098594188690186,0.5331838130950928,0.7193541526794434,0.785297155380249,0.8102703094482422,0.9763956069946289,1.25934362411499,1.429345607757568,1.391111612319946,1.251604557037354,1.166249513626099,1.186898946762085,1.27733588218689,1.344598531723022,1.377943754196167,1.36147141456604,1.243818998336792,1.036745309829712,0.7420492172241211,0.4136896133422852,0.1833879947662354,0.1415741443634033,0.2325654029846191,0.3705167770385742,0.4328691959381104,0.3644871711730957,0.201258659362793,-0.0397789478302002,-0.3039765357971191,-0.3828120231628418,-0.2243292331695557,-0.006526708602905273,0.1339530944824219,0.2445495128631592,0.4396176338195801,0.6805551052093506,0.7899284362792969,0.6542086601257324,0.4063117504119873,0.2881228923797607,0.2767825126647949,0.2909731864929199,0.3066229820251465,0.3128170967102051,0.2960050106048584,0.2088367938995361,0.1433587074279785,0.1509690284729004,0.1570808887481689,0.1666617393493652,0.3156602382659912,0.6131923198699951,0.8399319648742676,0.8220291137695312,0.584946870803833,0.2803802490234375,-0.0378870964050293,-0.2925145626068115,-0.4483187198638916,-0.5110681056976318,-0.514301061630249,-0.4045772552490234,-0.1569128036499023,0.08221864700317383,0.1539981365203857,0.08823037147521973,0.04377365112304688,0.08627414703369141,0.131453275680542,0.1142978668212891,0.01224160194396973,-0.04798293113708496,0.04378080368041992,0.2554857730865479,0.4768645763397217,0.6314563751220703,0.6548953056335449,0.5510866641998291,0.421367883682251,0.3409874439239502,0.2073276042938232,-0.006680488586425781,-0.134432315826416,-0.110621452331543,-0.0584721565246582,-0.06078958511352539,-0.08718252182006836,-0.1736569404602051,-0.317530632019043,-0.4625952243804932,-0.5817568302154541,-0.6449282169342041,-0.6131422519683838,-0.5322396755218506,-0.523449182510376,-0.5585110187530518,-0.5382406711578369,-0.6013691425323486,-0.787278413772583,-0.8994162082672119,-0.866246223449707,-0.7787239551544189,-0.6353080272674561,-0.4540550708770752,-0.407559871673584,-0.5576348304748535,-0.868910551071167,-1.208163499832153,-1.449329853057861,-1.473290920257568,-1.278859376907349,-0.9681129455566406,-0.663456916809082,-0.4729235172271729,-0.4213535785675049,-0.3482365608215332,-0.1894783973693848,-0.02398252487182617,0.03690719604492188,-0.003111362457275391,-0.109323263168335,-0.2376043796539307,-0.2913451194763184,-0.3212285041809082,-0.4403185844421387,-0.587918758392334,-0.6188249588012695,-0.5098092555999756,-0.3178131580352783,-0.09311914443969727,0.03642439842224121,0.01684069633483887,-0.07760167121887207,-0.1941812038421631,-0.3314495086669922,-0.4814887046813965,-0.6879258155822754,-0.9601306915283203,-1.256747245788574,-1.402269601821899,-1.315634250640869,-1.129478216171265,-0.9685349464416504,-0.8972346782684326,-0.9394276142120361,-1.046669483184814,-1.074478626251221,-1.069142818450928,-1.178126335144043,-1.307541131973267,-1.239209175109863,-0.9534430503845215,-0.5829548835754395,-0.3650128841400146,-0.4267537593841553,-0.5415523052215576,-0.3993415832519531,-0.08538365364074707,0.08450746536254883,0.08068084716796875,0.1059365272521973,0.1573312282562256,0.1311492919921875,0.1200950145721436,0.2518486976623535,0.4945778846740723,0.7163286209106445,0.8562755584716797,0.9902822971343994,1.143887042999268,1.174067258834839,1.095689535140991,1.03753924369812,1.048243045806885,1.050800085067749,1.023824214935303,1.092753410339355,1.217004060745239,1.192867755889893,1.020051240921021,0.8879756927490234,0.8177053928375244,0.7073235511779785,0.5619335174560547,0.4758024215698242,0.4633355140686035,0.4436659812927246,0.3927969932556152,0.3880476951599121,0.4622125625610352,0.5637180805206299,0.772712230682373,1.104991436004639,1.344147920608521,1.327564716339111,1.19043231010437,0.9944665431976318,0.729900598526001,0.5605673789978027,0.6672155857086182,0.8755123615264893,0.9469056129455566,1.002599000930786,1.205588579177856,1.385740041732788,1.365891695022583,1.281516551971436,1.291437149047852,1.277425289154053,1.191515922546387,1.194280385971069,1.277260780334473,1.290045976638794,1.256775856018066,1.253968477249146,1.252874135971069,1.197620630264282,1.155688762664795,1.190747022628784,1.24369740486145,1.160956621170044,0.9014332294464111,0.6188642978668213,0.4535830020904541,0.4426109790802002,0.6007254123687744,0.8340167999267578,0.9595906734466553,0.9560108184814453,0.8932006359100342,0.7418560981750488,0.4969346523284912,0.2303552627563477,0.04689216613769531,0.008715391159057617,0.102163553237915,0.1743757724761963,0.1102709770202637,-0.0618588924407959,-0.2084004878997803,-0.2571415901184082,-0.2062046527862549,-0.1030933856964111,-0.007764101028442383,0.06242752075195312,0.1693403720855713,0.3281629085540771,0.519644021987915,0.6064367294311523,0.5093085765838623,0.304419994354248,0.1105356216430664,0.03247976303100586,0.01819252967834473,-0.1068985462188721,-0.3552782535552979,-0.5861949920654297,-0.7252621650695801,-0.7601594924926758,-0.6878435611724854,-0.6305980682373047,-0.7095372676849365,-0.9196686744689941,-1.178752183914185,-1.372400522232056,-1.447566747665405,-1.498006582260132,-1.539630889892578,-1.447151899337769,-1.13717794418335,-0.7269859313964844,-0.4624557495117188,-0.4340207576751709,-0.5835521221160889,-0.852663516998291,-1.132292747497559,-1.307440996170044,-1.293500661849976,-1.180962324142456,-1.022014617919922,-0.8351898193359375,-0.6398677825927734,-0.4941809177398682,-0.4229378700256348,-0.3936982154846191,-0.3550136089324951,-0.3350293636322021,-0.4165220260620117,-0.637056827545166,-0.9715282917022705,-1.285797357559204,-1.401218175888062,-1.270880699157715,-1.036663055419922,-0.8241140842437744,-0.634925365447998,-0.5165863037109375,-0.5176055431365967,-0.5948853492736816,-0.596233606338501,-0.4518914222717285,-0.2831268310546875,-0.1551854610443115,-0.1327693462371826,-0.191495418548584,-0.3790926933288574,-0.6680452823638916,-0.8605527877807617,-0.9083282947540283,-0.9051811695098877,-0.9055852890014648,-0.8698225021362305,-0.8285558223724365,-0.8389949798583984,-0.8763277530670166,-0.9475278854370117,-1.03695273399353,-1.044548749923706,-0.891348123550415,-0.6131458282470703,-0.3433871269226074,-0.1883053779602051,-0.1736462116241455,-0.1851832866668701,-0.1876974105834961,-0.1653707027435303,-0.06640434265136719,0.05179882049560547,0.06215929985046387,0.09050130844116211,0.2302980422973633,0.319054126739502,0.2183032035827637,0.06208419799804688,0.01737356185913086,0.1113581657409668,0.3189325332641602,0.5309629440307617,0.5746114253997803,0.377572774887085,0.07599949836730957,-0.1138293743133545,-0.1800656318664551,-0.2308022975921631,-0.2308094501495361,-0.06135463714599609,0.2541160583496094,0.5373787879943848,0.7096731662750244,0.7302474975585938,0.5738532543182373,0.4117226600646973,0.3890132904052734,0.4813671112060547,0.56496262550354,0.5761170387268066,0.4926574230194092,0.3853726387023926,0.4263746738433838,0.6179416179656982,0.7457971572875977,0.7756912708282471,0.8749258518218994,1.094348430633545,1.302423477172852,1.471366882324219,1.60759449005127,1.666756868362427,1.634119749069214,1.560301780700684,1.603900194168091,1.740603446960449,1.799386739730835,1.76521897315979,1.770744323730469,1.802476644515991,1.794290542602539,1.8009352684021,1.95930004119873,2.159339189529419,2.133214473724365,1.95256233215332,1.893442869186401,1.925457715988159,1.833286285400391,1.734577417373657,1.798596382141113,1.81115984916687,1.600091457366943,1.318727731704712,1.132593154907227,0.9862911701202393,0.887296199798584,0.9309840202331543,1.090103387832642,1.227486133575439,1.228247880935669,1.147034168243408,1.049269437789917,0.9812736511230469,0.9099805355072021,0.7712531089782715,0.6903970241546631,0.8068156242370605,0.8968734741210938,0.7181811332702637,0.4939448833465576,0.4729020595550537,0.431363582611084,0.1994705200195312,0.03878116607666016,0.09262204170227051,0.1630282402038574,0.1474714279174805,0.06881475448608398,-0.07863163948059082,-0.3242218494415283,-0.6362736225128174,-0.9115791320800781,-1.051168441772461,-1.061131954193115,-0.9989941120147705,-0.8891737461090088,-0.7660460472106934,-0.716317892074585,-0.7845532894134521,-1.005896329879761,-1.274582147598267,-1.493343114852905,-1.694090366363525,-1.904597282409668,-2.000470161437988,-1.976391077041626,-1.981855630874634,-2.072099447250366,-2.025253772735596,-1.785192489624023,-1.557154655456543,-1.569314002990723,-1.827192306518555,-2.125536203384399,-2.321949005126953,-2.349679470062256,-2.236390113830566,-1.961603164672852,-1.530110836029053,-1.236273050308228,-1.258041858673096,-1.338669061660767,-1.358935832977295,-1.530708074569702,-1.80942177772522,-1.886748075485229,-1.758177280426025,-1.584645509719849,-1.360194683074951,-1.087270975112915,-0.9002888202667236,-0.8525991439819336,-0.8199763298034668,-0.7366132736206055,-0.657881498336792,-0.6481647491455078,-0.6783628463745117,-0.709083080291748,-0.7735347747802734,-0.8376753330230713,-0.7884299755096436,-0.6560611724853516,-0.5233418941497803,-0.3653812408447266,-0.07936477661132812,0.2366816997528076,0.3296113014221191,0.1460230350494385,-0.2006006240844727,-0.6119048595428467,-0.9683167934417725,-1.049011945724487,-0.7622766494750977,-0.234990119934082,0.3972172737121582,0.9646761417388916,1.276270151138306,1.269010305404663,1.059411764144897,0.8289992809295654,0.6952714920043945,0.7333230972290039,0.9349393844604492,1.138161420822144,1.202230453491211,1.191229820251465,1.163749694824219,1.028659343719482,0.8520591259002686,0.8125054836273193,0.8892917633056641,0.951848030090332,1.003736257553101,1.259933710098267,1.72575831413269,2.097491025924683,2.176448106765747,2.116080522537231,2.110612392425537,2.127317190170288,2.125285863876343,2.171130180358887,2.202887535095215,2.09531307220459,1.900681257247925,1.774710416793823,1.753588914871216,1.726366281509399,1.668645143508911,1.598896980285645,1.509207487106323,1.457748413085938,1.441758871078491,1.407480239868164,1.364911794662476,1.385847330093384,1.355792284011841,1.217665672302246,1.092098951339722,1.0303795337677,0.9770214557647705,0.8564651012420654,0.7724297046661377,0.8815348148345947,1.114468574523926,1.244047880172729,1.162573099136353,0.8558106422424316,0.3955471515655518,-0.02579569816589355,-0.2878081798553467,-0.4312312602996826,-0.5691111087799072,-0.7890915870666504,-1.080855131149292,-1.184288263320923,-1.005202531814575,-0.7728445529937744,-0.6739926338195801,-0.6684815883636475,-0.7021164894104004,-0.774611234664917,-0.7629740238189697,-0.6912946701049805,-0.7168471813201904,-0.8518660068511963,-0.9807157516479492,-1.066464185714722,-1.115834712982178,-1.129717826843262,-1.117969751358032,-1.104912757873535,-1.054372787475586,-0.9856832027435303,-1.022125482559204,-1.198968887329102,-1.454100608825684,-1.7376708984375,-1.906932592391968,-1.839079856872559,-1.639688014984131,-1.516309976577759,-1.517318487167358,-1.574023962020874,-1.728197336196899,-2.059718370437622,-2.404396533966064,-2.498660087585449,-2.359585762023926,-2.150834798812866,-1.860605478286743,-1.428329944610596,-1.069933176040649,-1.075730323791504,-1.300063133239746,-1.357977390289307,-1.24503493309021,-1.15788459777832,-1.088014841079712,-0.9054172039031982,-0.7438766956329346,-0.7029426097869873,-0.6826579570770264,-0.6333410739898682,-0.5754768848419189,-0.4812240600585938,-0.3685140609741211,-0.2746224403381348,-0.0967705249786377,0.1905477046966553,0.3482186794281006,0.2850794792175293,0.1465487480163574,0.1572132110595703,0.3078603744506836,0.4798042774200439,0.6205201148986816,0.6863522529602051,0.665738582611084,0.6302189826965332,0.7385730743408203,0.9922671318054199,1.068795919418335,0.8997988700866699,0.7727980613708496,0.8180630207061768,0.8979213237762451,0.9014225006103516,0.813910961151123,0.5587327480316162,0.1797723770141602,-0.09405255317687988,-0.03963947296142578,0.3539693355560303,0.8358871936798096,1.169686317443848,1.320090293884277,1.368023157119751,1.314035654067993,1.083966493606567,0.7894492149353027,0.6010580062866211,0.4844570159912109,0.48622727394104,0.7728767395019531,1.204208135604858,1.517761945724487,1.564410924911499,1.34907603263855,1.036680936813354,0.9322500228881836,1.179481744766235,1.551804542541504,1.765379905700684,1.778959035873413,1.650452613830566,1.467175483703613,1.270369291305542,1.093136072158813,0.9024918079376221,0.7617080211639404,0.6981861591339111,0.6068694591522217,0.4503965377807617,0.3256022930145264,0.2899038791656494,0.2107751369476318,-0.006219148635864258,-0.2433300018310547,-0.4349863529205322,-0.6449532508850098,-0.8075129985809326,-0.8180952072143555,-0.7556426525115967,-0.7714319229125977,-0.8190786838531494,-0.8308553695678711,-0.9027528762817383,-1.005134582519531,-1.007158756256104,-0.8926713466644287,-0.7612574100494385,-0.6694686412811279,-0.6609678268432617,-0.7502210140228271,-0.7865595817565918,-0.6931114196777344,-0.5798256397247314,-0.4732131958007812,-0.3942382335662842,-0.4424357414245605,-0.5279445648193359,-0.4991269111633301,-0.3894567489624023,-0.236670970916748,-0.07827401161193848,-0.01076459884643555,-0.06628274917602539,-0.1022994518280029,-0.1170766353607178,-0.185312032699585,-0.2909302711486816,-0.3396105766296387,-0.2753663063049316,-0.1645159721374512,-0.1322436332702637,-0.2975821495056152,-0.5800437927246094,-0.7362556457519531,-0.7347214221954346,-0.7888913154602051,-0.9478676319122314,-0.8967912197113037,-0.458303689956665,0.13633131980896,0.6462013721466064,0.9986007213592529,1.078798770904541,0.8773899078369141,0.5588293075561523,0.2583217620849609,-0.1006865501403809,-0.458528995513916,-0.6380975246429443,-0.6364703178405762,-0.5449891090393066,-0.4185748100280762,-0.3243649005889893,-0.2884554862976074,-0.2537477016448975,-0.1418209075927734,0.01773476600646973,0.1001572608947754,0.1318717002868652,0.2311956882476807,0.3113937377929688,0.3606998920440674,0.5064153671264648,0.7173514366149902,0.7776975631713867,0.6848537921905518,0.5615866184234619,0.3834807872772217,0.1610040664672852,0.02948284149169922,-0.005074739456176758,-0.0646054744720459,-0.1852476596832275,-0.2987408638000488,-0.3750121593475342,-0.4065585136413574,-0.4898357391357422,-0.6094372272491455,-0.5756092071533203,-0.3608572483062744,-0.1944422721862793,-0.2667546272277832,-0.5107784271240234,-0.7228374481201172,-0.7387912273406982,-0.6019771099090576,-0.4231166839599609,-0.1940667629241943,0.02417922019958496,0.04670619964599609,-0.06400108337402344,-0.0621485710144043,0.05580782890319824,0.1076710224151611,0.1121377944946289,0.1778805255889893,0.324629545211792,0.4410374164581299,0.5578780174255371,0.7201159000396729,0.8785521984100342,0.9869349002838135,0.9828865528106689,0.8678770065307617,0.8477210998535156,0.9949600696563721,1.028237342834473,0.8408439159393311,0.7025992870330811,0.650181770324707,0.3883302211761475,-0.1790392398834229,-0.6679308414459229,-0.7902395725250244,-0.7125198841094971,-0.5904722213745117,-0.3865921497344971,-0.1913917064666748,-0.3189253807067871,-0.7914233207702637,-1.177786588668823,-1.256221532821655,-1.226474046707153,-1.157162189483643,-0.9071803092956543,-0.6588613986968994,-0.6926608085632324,-0.7818889617919922,-0.749051570892334,-0.7601308822631836,-0.8068585395812988,-0.654062032699585,-0.3609859943389893,-0.1693260669708252,-0.01016736030578613,0.2413487434387207,0.4502391815185547,0.582582950592041,0.7287025451660156,0.894312858581543,0.9502637386322021,0.9380757808685303,1.077393293380737,1.324889659881592,1.31029486656189,0.9454250335693359,0.6971454620361328,0.7702267169952393,0.9146761894226074,1.08863353729248,1.266524791717529,1.18686318397522,0.8682560920715332,0.6702303886413574,0.6871962547302246,0.854644775390625,1.128737926483154,1.396007537841797,1.485657691955566,1.45877480506897,1.456292867660522,1.366328001022339,1.026449203491211,0.5974996089935303,0.3516662120819092,0.2442061901092529,0.2230453491210938,0.3640437126159668,0.5844461917877197,0.6962835788726807,0.643007755279541,0.5268645286560059,0.3987300395965576,0.1701521873474121,-0.1388347148895264,-0.3402471542358398,-0.2342498302459717,0.02366065979003906,0.1205778121948242,0.1280629634857178,0.2918672561645508,0.5260562896728516,0.7380616664886475,0.9426212310791016,1.014171838760376,0.6929111480712891,0.1751089096069336,-0.109105110168457,-0.06375432014465332,0.07390379905700684,0.1167905330657959,0.007728338241577148,-0.2275121212005615,-0.4616332054138184,-0.6355011463165283,-0.7532644271850586,-0.6753122806549072,-0.4207456111907959,-0.249563455581665,-0.2740073204040527,-0.36537766456604,-0.4533576965332031,-0.5849504470825195,-0.720062255859375,-0.7610321044921875,-0.6811201572418213,-0.5250942707061768,-0.2776908874511719,0.07248044013977051,0.3895461559295654,0.5255234241485596,0.3463411331176758,-0.0433051586151123,-0.205761194229126,-0.0470423698425293,0.03065943717956543,-0.1411056518554688,-0.2085435390472412,-0.02707600593566895,0.05862236022949219,-0.05469560623168945,-0.06575703620910645,-0.01007080078125,-0.1766538619995117,-0.3308773040771484,-0.1707923412322998,0.04979968070983887,-0.07827043533325195,-0.4208958148956299,-0.7642793655395508,-1.150835752487183,-1.51860237121582,-1.576766967773438,-1.319553852081299,-1.020916700363159,-0.9206020832061768,-0.9922313690185547,-1.018291711807251,-0.9779119491577148,-1.033744812011719,-1.199401617050171,-1.38485312461853,-1.506221294403076,-1.52276873588562,-1.511210203170776,-1.579445600509644,-1.794919967651367,-2.046500444412231,-2.212579250335693,-2.230786085128784,-2.050101757049561,-1.784305572509766,-1.706535816192627,-1.781988143920898,-1.746343374252319,-1.617379188537598,-1.481763124465942,-1.275472640991211,-0.9651660919189453,-0.7224404811859131,-0.631481409072876,-0.4237890243530273,-0.1103889942169189,-0.0598454475402832,-0.2874219417572021,-0.4273509979248047,-0.4708170890808105,-0.6042301654815674,-0.7115864753723145,-0.5352902412414551,-0.2233207225799561,-0.06557106971740723,-0.05563616752624512,-0.04047632217407227,-0.0856482982635498,-0.1753520965576172,-0.1221978664398193,0.1079285144805908,0.235297679901123,0.1378011703491211,0.01366496086120605,-0.04514336585998535,-0.2062833309173584,-0.3513514995574951,-0.2202737331390381,0.1257741451263428,0.3907477855682373,0.3735744953155518,0.119926929473877,-0.2257204055786133,-0.5596768856048584,-0.83396315574646,-0.9806156158447266,-0.9563183784484863,-0.7317245006561279,-0.3530359268188477,-0.06006717681884766,0.05405902862548828,0.1709854602813721,0.4227519035339355,0.6023526191711426,0.6055140495300293,0.7220864295959473,1.020627021789551,1.157845258712769,1.180436611175537,1.428258419036865,1.733325719833374,1.698067188262939,1.490582227706909,1.506915092468262,1.746683120727539,2.018963098526001,2.217403650283813,2.311699390411377,2.29804515838623,2.244118452072144,2.204718589782715,2.285696268081665,2.537623643875122,2.788900136947632,2.950626611709595,2.967574596405029,2.797958850860596,2.54891037940979,2.345244884490967,2.208731174468994,2.173930406570435,2.162847518920898,2.049980163574219,1.807408332824707,1.517547369003296,1.276813745498657,1.097456216812134,0.8852541446685791,0.7475173473358154,0.7260417938232422,0.6806266307830811,0.6189179420471191,0.6501495838165283,0.6825900077819824,0.5494809150695801,0.3626883029937744,0.4150557518005371,0.7611358165740967,0.9684920310974121,0.7340991497039795,0.3973710536956787,0.1773226261138916,-0.09987831115722656,-0.2832698822021484,-0.01978039741516113,0.4065227508544922,0.486295223236084,0.4032719135284424,0.4906010627746582,0.5705702304840088,0.3997170925140381,0.1979470252990723,0.153118371963501,0.1103568077087402,-0.001158714294433594,-0.06449460983276367,-0.103229284286499,-0.2594876289367676,-0.5299830436706543,-0.7980430126190186,-1.035436391830444,-1.177407503128052,-1.160169839859009,-1.063041687011719,-0.9812486171722412,-0.808027982711792,-0.4983687400817871,-0.3384912014007568,-0.3815531730651855,-0.2821969985961914,-0.03829479217529297,0.003529787063598633,-0.04507184028625488,0.1442956924438477,0.3238928318023682,0.1143550872802734,-0.2145159244537354,-0.287858247756958,-0.4159533977508545,-0.7747364044189453,-0.9091293811798096,-0.6571018695831299,-0.4587078094482422,-0.5294287204742432,-0.5567264556884766,-0.417022705078125,-0.3859627246856689,-0.4517483711242676,-0.329890251159668,-0.08825540542602539,-0.08707165718078613,-0.4144549369812012,-0.7803869247436523,-0.8534824848175049,-0.6888842582702637,-0.6145763397216797,-0.7949173450469971,-0.9227550029754639,-0.8408474922180176,-0.8350610733032227,-1.095782518386841,-1.233150959014893,-1.071592569351196,-1.061639785766602,-1.398711204528809,-1.793521642684937,-2.017675638198853,-2.242777347564697,-2.450355291366577,-2.25127100944519,-1.66277289390564,-1.138168573379517,-0.8729732036590576,-0.6627023220062256,-0.4433262348175049,-0.2834594249725342,-0.2511370182037354,-0.4167473316192627,-0.6220149993896484,-0.6297111511230469,-0.4396319389343262,-0.1673376560211182,0.07277011871337891,0.1768326759338379,0.0547027587890625,-0.2631604671478271,-0.4713141918182373,-0.4241359233856201,-0.299917459487915,-0.1827621459960938,-0.01436948776245117,0.2439737319946289,0.4626059532165527,0.5165362358093262,0.3536081314086914,0.07705450057983398,-0.1084935665130615,-0.1007580757141113,0.01189112663269043,0.1819932460784912,0.4104065895080566,0.5858516693115234,0.5723297595977783,0.3804874420166016,0.1303410530090332,-0.01433014869689941,-0.0394749641418457,0.02496242523193359,0.1890313625335693,0.4653525352478027,0.6564974784851074,0.5699801445007324,0.3315317630767822,0.1580214500427246,0.0602567195892334,-0.0005400180816650391,0.08318424224853516,0.2217400074005127,0.1280307769775391,-0.2200734615325928,-0.472412109375,-0.3853011131286621,-0.1251626014709473,0.1609361171722412,0.5292963981628418,0.8142149448394775,0.7522130012512207,0.5679380893707275,0.6163144111633301,0.8203697204589844,0.9383940696716309,1.041362285614014,1.216081380844116,1.365201473236084,1.391361951828003,1.368663311004639,1.365119218826294,1.276599168777466,1.120287179946899,1.003689765930176,0.9275257587432861,0.8540689945220947,0.8365201950073242,0.8582961559295654,0.7194042205810547,0.4160642623901367,0.1967740058898926,0.1728880405426025,0.2986299991607666,0.5933511257171631,1.068241596221924,1.452827453613281,1.461224555969238,1.174736022949219,0.8392524719238281,0.5628848075866699,0.4606425762176514,0.5440449714660645,0.6439018249511719,0.6864166259765625,0.8182704448699951,1.093118190765381,1.30278468132019,1.259862184524536,1.067901849746704,0.8573377132415771,0.6490552425384521,0.6148338317871094,0.8044159412384033,1.049398183822632,1.185550689697266,1.235908269882202,1.290786266326904,1.313914060592651,1.228562593460083,1.111536026000977,1.016585826873779,0.8246934413909912,0.4869067668914795,0.2237319946289062,0.1884806156158447,0.1514518260955811,-0.07555961608886719,-0.2590513229370117,-0.3305304050445557,-0.4866564273834229,-0.8004570007324219,-1.1417555809021,-1.484988927841187,-1.790152788162231,-1.982871294021606,-2.087244987487793,-2.126455307006836,-2.240642309188843,-2.460383176803589,-2.544808387756348,-2.349815368652344,-2.186125516891479,-2.23980188369751,-2.238593101501465,-2.068033218383789,-1.915197372436523,-1.837881803512573,-1.77238941192627,-1.714893579483032,-1.706696748733521,-1.59417986869812,-1.248142719268799,-0.7700121402740479,-0.3727877140045166,-0.1593947410583496,-0.0787818431854248,-0.1380693912506104,-0.3023922443389893,-0.3972458839416504,-0.2406299114227295,0.04043340682983398,0.2591979503631592,0.3979897499084473,0.4059863090515137,0.2631998062133789,0.2147161960601807,0.4550027847290039,0.6607246398925781,0.5913949012756348,0.5873966217041016,0.9088540077209473,1.354218721389771,1.614217758178711,1.622014045715332,1.433268785476685,1.136713027954102,0.9052741527557373,0.8362483978271484,0.9559142589569092,1.120601892471313,1.218971014022827,1.144695281982422,0.8691680431365967,0.5602169036865234,0.4273653030395508,0.4905009269714355,0.6532537937164307,0.8690822124481201,1.10012412071228,1.155799627304077,0.9798359870910645,0.635533332824707,0.2247476577758789,-0.04126667976379395,0.01926898956298828,0.2020061016082764,0.3375363349914551,0.5758917331695557,0.9286129474639893,1.111360788345337,1.082442998886108,1.018931865692139,0.9864234924316406,0.9479999542236328,0.8826005458831787,0.8135747909545898,0.7494878768920898,0.7064330577850342,0.6154632568359375,0.5171871185302734,0.5403721332550049,0.7505929470062256,1.003961563110352,1.063549518585205,0.8940517902374268,0.6845247745513916,0.5371391773223877,0.4512584209442139,0.4156208038330078,0.4322218894958496,0.498121976852417,0.6314241886138916,0.8630132675170898,1.032840013504028,0.8729946613311768,0.5023670196533203,0.2979719638824463,0.2575457096099854,0.03842711448669434,-0.3498709201812744,-0.6231379508972168,-0.719597339630127,-0.6534504890441895,-0.3421211242675781,-0.05174875259399414,-0.08478999137878418,-0.313103199005127,-0.4952645301818848,-0.6624555587768555,-0.7784271240234375,-0.7022666931152344,-0.5585289001464844,-0.5441737174987793,-0.7388341426849365,-0.9526240825653076,-0.9908616542816162,-0.9349966049194336,-1.006296873092651,-1.248157024383545,-1.488543748855591,-1.557265520095825,-1.543625593185425,-1.491068601608276,-1.297860145568848,-1.094026565551758,-1.009769439697266,-1.012455224990845,-1.091841459274292,-1.217365264892578,-1.389956474304199,-1.502780914306641,-1.560208797454834,-1.638057231903076,-1.703996658325195,-1.614940166473389,-1.397037506103516,-1.359279155731201,-1.441032886505127,-1.321227550506592,-1.013588905334473,-0.8664608001708984,-0.8510148525238037,-0.8085787296295166,-0.7888555526733398,-0.9672653675079346,-1.214962005615234,-1.253957748413086,-1.063220500946045,-0.8087003231048584,-0.6518697738647461,-0.6375682353973389,-0.7089221477508545,-0.7189428806304932,-0.6899642944335938,-0.695418119430542,-0.6575489044189453,-0.5682098865509033,-0.3891563415527344,-0.05490660667419434,0.2135467529296875,0.2330124378204346,0.218052864074707,0.3868818283081055,0.6922709941864014,0.9330618381500244,0.9753656387329102,0.9296572208404541,0.8857405185699463,0.8420741558074951,0.8049380779266357,0.8846461772918701,1.001626253128052,0.8922171592712402,0.7887554168701172,1.019060611724854,1.307562589645386,1.38552188873291,1.528465747833252,1.786855459213257,1.840918064117432,1.573351621627808,1.256439685821533,1.090432405471802,1.143465042114258,1.406850814819336,1.645914316177368,1.839934587478638,2.184841632843018,2.612389326095581,2.793842554092407,2.683010101318359,2.460769414901733,2.257765531539917,2.107908725738525,2.02272891998291,1.984906196594238,1.950595378875732,1.860848665237427,1.748603582382202,1.669857501983643,1.505023241043091,1.246547698974609,1.055856943130493,0.9105777740478516,0.9110820293426514,1.172225475311279,1.525990962982178,1.598457098007202,1.360559463500977,1.0358726978302,0.6516945362091064,0.2700090408325195,0.02779483795166016,0.0796043872833252,0.4152238368988037,0.7877719402313232,0.8494341373443604,0.5995666980743408,0.2248692512512207,-0.1647341251373291,-0.5214107036590576,-0.9150874614715576,-1.259572505950928,-1.411850452423096,-1.421706676483154,-1.382825374603271,-1.165376901626587,-0.7454323768615723,-0.4735672473907471,-0.5018341541290283,-0.5081892013549805,-0.341484546661377,-0.2858483791351318,-0.4271256923675537,-0.6471812725067139,-1.008017063140869,-1.519095897674561,-1.924295425415039,-1.990982294082642,-1.930221319198608,-1.953281164169312,-1.88482403755188,-1.720433235168457,-1.661778688430786,-1.703485250473022,-1.619921922683716,-1.437098979949951,-1.338368654251099,-1.343547105789185,-1.193879842758179,-0.9116935729980469,-0.8168792724609375,-0.8336877822875977,-0.7566118240356445,-0.6287598609924316,-0.4648518562316895,-0.09610533714294434,0.2903759479522705,0.3940200805664062,0.3669905662536621,0.4640579223632812,0.5685997009277344,0.504906177520752,0.4073989391326904,0.4326653480529785,0.5332767963409424,0.7324755191802979,1.09255313873291,1.359626054763794,1.336215734481812,1.067136526107788,0.652763843536377,0.2207851409912109,0.0358736515045166,0.1897001266479492,0.4773366451263428,0.638197660446167,0.6006073951721191,0.5912590026855469,0.6102204322814941,0.3123271465301514,-0.2906155586242676,-0.8450996875762939,-1.164028644561768,-1.305134296417236,-1.301969289779663,-1.161332130432129,-1.127883195877075,-1.369972229003906,-1.683597564697266,-1.84619665145874,-1.878547668457031,-1.865690946578979,-1.811982393264771,-1.733071804046631,-1.584863662719727,-1.445631980895996,-1.367161273956299,-1.375401020050049,-1.610759496688843,-1.969571113586426,-2.191818952560425,-2.192040681838989,-2.113544940948486,-2.111907005310059,-2.065730094909668,-1.842670440673828,-1.637080907821655,-1.638990640640259,-1.648539304733276,-1.457161903381348,-1.230758428573608,-1.094487905502319,-0.9028422832489014,-0.6978285312652588,-0.537872314453125,-0.3456902503967285,-0.1296150684356689,-0.04363417625427246,-0.1787424087524414,-0.449531078338623,-0.6814277172088623,-0.6920886039733887,-0.4617083072662354,-0.1696264743804932,0.09410977363586426,0.3771579265594482,0.5979430675506592,0.5100524425506592,0.2388203144073486,0.1540052890777588,0.2728664875030518,0.4217398166656494,0.4766213893890381,0.3947460651397705,0.3121590614318848,0.3676128387451172,0.4336452484130859,0.293201208114624,0.09694218635559082,0.06586790084838867,0.09524703025817871,0.01326441764831543,-0.04169940948486328,-0.02344608306884766,-0.08281588554382324,-0.115206241607666,0.09445309638977051,0.4322361946105957,0.5781018733978271,0.5225908756256104,0.5459046363830566,0.7706952095031738,0.9742569923400879,0.9550631046295166,1.033684015274048,1.380497217178345,1.725572347640991,1.843811273574829,1.970622539520264,2.100609540939331,1.98401927947998,1.81957483291626,1.756739616394043,1.648192405700684,1.503124237060547,1.417994499206543,1.36181116104126,1.342552900314331,1.437867879867554,1.489505767822266,1.261904239654541,0.9689211845397949,0.8415412902832031,0.7804548740386963,0.687636137008667,0.5873823165893555,0.5675411224365234,0.6354081630706787,0.7706880569458008,0.932772159576416,1.089520454406738,1.212104558944702,1.156253814697266,0.9623372554779053,0.7238674163818359,0.3151524066925049,-0.2623450756072998,-0.6518447399139404,-0.677025318145752,-0.475623607635498,-0.1738965511322021,0.05977749824523926,0.02910375595092773,-0.2124309539794922,-0.5130887031555176,-0.8688390254974365,-1.078230142593384,-0.9519767761230469,-0.7094299793243408,-0.6371498107910156,-0.6386947631835938,-0.5130350589752197,-0.428009033203125,-0.4888236522674561,-0.6134140491485596,-0.6490945816040039,-0.4638111591339111,-0.04059791564941406,0.3951001167297363,0.5456900596618652,0.5597090721130371,0.6153380870819092,0.6549382209777832,0.613936185836792,0.6202733516693115,0.6607925891876221,0.6233131885528564,0.5310165882110596,0.424497127532959,0.299452543258667,0.1710426807403564,0.1165974140167236,0.1046633720397949,0.1423788070678711,0.2493166923522949,0.3689932823181152,0.3731381893157959,0.2958691120147705,0.3129851818084717,0.378953218460083,0.4222512245178223,0.4930973052978516,0.5807161331176758,0.5417132377624512,0.3803122043609619,0.3151845932006836,0.4121840000152588,0.4213929176330566,0.1029002666473389,-0.3046238422393799,-0.4780340194702148,-0.5921745300292969,-0.8049595355987549,-0.8072483539581299,-0.5704414844512939,-0.4624772071838379,-0.5566620826721191,-0.5642938613891602,-0.5525064468383789,-0.6841957569122314,-0.997159481048584,-1.497237682342529,-1.964274644851685,-2.131497859954834,-2.097880840301514,-2.041025161743164,-1.935932636260986,-1.764532327651978,-1.661134958267212,-1.688672304153442,-1.7514967918396,-1.771988868713379,-1.882896423339844,-2.05079197883606,-1.959711313247681,-1.756120920181274,-1.845570802688599,-2.122650146484375,-2.158255577087402,-2.109056711196899,-2.319220304489136,-2.516863346099854,-2.3816978931427,-2.210966348648071,-2.212647199630737,-2.09479808807373,-1.824460029602051,-1.708159446716309,-1.75014853477478,-1.748424768447876,-1.688708066940308,-1.575522422790527,-1.36397123336792,-1.176234483718872,-1.104841232299805,-1.042013168334961,-0.796884298324585,-0.3943884372711182,-0.074615478515625,-0.03686785697937012,-0.2358877658843994,-0.5423498153686523,-0.816882848739624,-0.8475387096405029,-0.6229627132415771,-0.4342854022979736,-0.4185783863067627,-0.3297293186187744,-0.1033186912536621,-0.1372647285461426,-0.4206240177154541,-0.4805588722229004,-0.2859377861022949,-0.08977174758911133,0.1306056976318359,0.5179345607757568,0.7425355911254883,0.418771505355835,-0.1143515110015869,-0.2901363372802734,-0.1606464385986328,-0.1483869552612305,-0.2502000331878662,-0.1071739196777344,0.2468383312225342,0.3610467910766602,0.152592658996582,-0.01792073249816895,-0.1779842376708984,-0.5267536640167236,-0.7842957973480225,-0.672154426574707,-0.3985333442687988,-0.1809310913085938,-0.02084612846374512,0.01598238945007324,0.008597373962402344,0.1805233955383301,0.4662108421325684,0.6211209297180176,0.5691862106323242,0.3689718246459961,0.1671266555786133,0.2245008945465088,0.4995203018188477,0.7350969314575195,0.7902216911315918,0.8039867877960205,0.9472060203552246,1.319364309310913,1.801668405532837,2.083722352981567,2.222181558609009,2.424277067184448,2.662575244903564,2.746717929840088,2.760286331176758,2.703090906143188,2.42423415184021,1.889169216156006,1.359636783599854,1.098153591156006,1.102008819580078,1.2226402759552,1.508399248123169,1.941661834716797,2.300537824630737,2.374849319458008,2.274187803268433,2.072124481201172,1.563205718994141,0.8502280712127686,0.4182708263397217,0.3431153297424316,0.4155921936035156,0.6148731708526611,0.8183276653289795,0.7733058929443359,0.5636751651763916,0.4525244235992432,0.4480218887329102,0.3114688396453857,-0.006308555603027344,-0.2560722827911377,-0.09797930717468262,0.1764965057373047,0.2949464321136475,0.4520630836486816,0.6558680534362793,0.5671012401580811,0.2422928810119629,0.03976821899414062,-0.03814816474914551,-0.255357027053833,-0.5430972576141357,-0.6156241893768311,-0.3766250610351562,-0.0992739200592041,-0.1207602024078369,-0.3802049160003662,-0.6724655628204346,-0.9808874130249023,-1.449569463729858,-1.969478130340576,-2.251335382461548,-2.314928770065308,-2.365661859512329,-2.439168691635132,-2.57979154586792,-2.772778272628784,-2.803115844726562,-2.694811820983887,-2.716999053955078,-2.801642417907715,-2.675120830535889,-2.375328540802002,-2.159628868103027,-2.058573961257935,-1.949186325073242,-1.923322677612305,-2.067339420318604,-2.221924066543579,-2.136197090148926,-1.836916208267212,-1.574174165725708,-1.326920986175537,-1.101336479187012,-1.089577674865723,-1.476659774780273,-1.956710815429688,-2.053145170211792,-1.675307750701904,-1.122586727142334,-0.6664109230041504,-0.2929544448852539,0.07273435592651367,0.4775762557983398,0.7230770587921143,0.5768144130706787,0.2196049690246582,0.01907587051391602,0.06524562835693359,0.2670979499816895,0.5831730365753174,0.9297072887420654,1.109522581100464,1.167043447494507,1.189827919006348,1.2605881690979,1.2699294090271,1.083869934082031,0.6798791885375977,0.2499604225158691,0.2150988578796387,0.5389201641082764,0.7303547859191895,0.7209634780883789,0.6320786476135254,0.5057144165039062,0.4771041870117188,0.6416094303131104,0.8521020412445068,1.011636257171631,1.043676137924194,0.9537792205810547,0.932157039642334,1.05352520942688,1.065366268157959,0.9167969226837158,0.7527172565460205,0.5613541603088379,0.3420603275299072,0.3195905685424805,0.5867958068847656,0.949784517288208,1.268713474273682,1.590539216995239,1.971051692962646,2.078554630279541,1.70688271522522,1.237181425094604,0.9147262573242188,0.6027853488922119,0.3001391887664795,0.1868855953216553,0.2735245227813721,0.3415560722351074,0.1820862293243408,-0.1158714294433594,-0.2872753143310547,-0.1644301414489746,0.1077461242675781,0.2736175060272217,0.4204058647155762,0.6678271293640137,0.709691047668457,0.3061079978942871,-0.1527142524719238,-0.4138147830963135,-0.7837092876434326,-1.202620267868042,-1.254082918167114,-0.9155488014221191,-0.5947637557983398,-0.5734813213348389,-0.7416844367980957,-0.8710312843322754,-0.8999884128570557,-0.8862018585205078,-0.8713710308074951,-0.7756197452545166,-0.7629883289337158,-0.8551418781280518,-0.7393276691436768,-0.2730059623718262,0.07943272590637207,-0.02770543098449707,-0.1494669914245605,-0.007935762405395508,-0.03277301788330078,-0.4172301292419434,-0.7979071140289307,-1.029496192932129,-1.168259382247925,-1.08789324760437,-0.6801831722259521,-0.1408767700195312,0.2202987670898438,0.2866494655609131,0.1062691211700439,-0.2922070026397705,-0.7782840728759766,-1.171109676361084,-1.399630308151245,-1.44213080406189,-1.312930583953857,-1.095854043960571,-1.000803709030151,-1.106647253036499,-1.179438829421997,-1.168792247772217,-1.088933944702148,-1.023784875869751,-1.137703657150269,-1.3981032371521,-1.58301830291748,-1.513667106628418,-1.358757019042969,-1.322658061981201,-1.240675449371338,-0.8932399749755859,-0.414276123046875,-0.05928397178649902,0.1628708839416504,0.3121554851531982,0.345919132232666,0.2539122104644775,0.2990484237670898,0.5588293075561523,0.781170129776001,0.8455359935760498,0.930018424987793,1.188901662826538,1.453621387481689,1.484098434448242,1.270394325256348,0.9111177921295166,0.4854905605316162,0.1022529602050781,-0.01477718353271484,0.1546669006347656,0.231860876083374,-0.03312349319458008,-0.3466701507568359,-0.4188501834869385,-0.2867639064788818,-0.0815284252166748,0.04958868026733398,-0.1073920726776123,-0.4437446594238281,-0.8255124092102051,-1.227446794509888,-1.407691240310669,-1.197824478149414,-0.8351361751556396,-0.6139111518859863,-0.4678595066070557,-0.3588652610778809,-0.402456521987915,-0.549623966217041,-0.6612181663513184,-0.7531535625457764,-0.8481073379516602,-0.7388877868652344,-0.4571378231048584,-0.4059219360351562,-0.7612037658691406,-1.265287399291992,-1.648349761962891,-1.760287284851074,-1.615133285522461,-1.384692192077637,-1.334652900695801,-1.5440833568573,-1.816070079803467,-1.8648362159729,-1.758788824081421,-1.82713508605957,-1.969835758209229,-1.904904842376709,-1.770565509796143,-1.693754196166992,-1.509783267974854,-1.25902533531189,-1.208699941635132,-1.464393138885498,-1.743307113647461,-1.730732917785645,-1.393675804138184,-0.8480644226074219,-0.212252140045166,0.3004968166351318,0.5424070358276367,0.6829798221588135,0.970308780670166,1.285661458969116,1.315240859985352,1.089609861373901,0.916907787322998,0.9826862812042236,1.196726560592651,1.311321258544922,1.296426057815552,1.514604091644287,2.053177356719971,2.757446765899658,3.306841850280762,3.442407846450806,3.239389657974243,3.02648663520813,2.997035980224609,3.108590841293335,3.376632928848267,3.814290761947632,4.096287488937378,3.928617238998413,3.609205484390259,3.285770416259766,2.749146223068237,2.152894735336304,1.805824041366577,1.756303310394287,1.868430376052856,2.004604339599609,2.295362949371338,2.622538805007935,2.657243013381958,2.249754667282104,1.59943699836731,1.090654134750366,0.9222185611724854,0.971750020980835,0.8831691741943359,0.6230807304382324,0.4002249240875244,0.1626205444335938,-0.1595377922058105,-0.3515803813934326,-0.3529608249664307,-0.356898307800293,-0.2930188179016113,-0.01689434051513672,0.2201128005981445,0.2082574367523193,-0.0004613399505615234,-0.3128921985626221,-0.5957865715026855,-0.8991444110870361,-1.12501859664917,-1.144641637802124,-1.112397909164429,-1.210609674453735,-1.394745111465454,-1.481140851974487,-1.409515142440796,-1.222579479217529,-1.036466360092163,-0.9993982315063477,-1.181674003601074,-1.632106304168701,-2.208670377731323,-2.599672079086304,-2.710068225860596,-2.673654556274414,-2.632409334182739,-2.605201005935669,-2.690902948379517,-2.920814752578735,-3.142318725585938,-3.321508169174194,-3.546441793441772,-3.676890134811401,-3.542886972427368,-3.167295455932617,-2.660211324691772,-2.233350276947021,-2.132019996643066,-2.29680061340332,-2.396904230117798,-2.258620262145996,-1.907780170440674,-1.436762809753418,-1.053414344787598,-0.9242892265319824,-1.021753549575806,-1.088873147964478,-1.028509140014648,-1.123960018157959,-1.565537452697754,-1.92003607749939,-1.691086292266846,-1.140714883804321,-0.7402360439300537,-0.6348645687103271,-0.6952285766601562,-0.7377254962921143,-0.6872105598449707,-0.596315860748291,-0.4067766666412354,-0.1709389686584473,-0.09018659591674805,-0.1572203636169434,-0.1690149307250977,-0.04060149192810059,0.1726019382476807,0.5483615398406982,0.9872174263000488,1.215734481811523,1.302005052566528,1.278008222579956,0.8526813983917236,0.1462340354919434,-0.2815282344818115,-0.3591728210449219,-0.3326082229614258,-0.2147912979125977,-0.005153417587280273,0.2236497402191162,0.4990088939666748,0.7034146785736084,0.78177809715271,0.6172192096710205,0.38901686668396,0.4169940948486328,0.757366418838501,1.147195100784302,1.502230167388916,2.024316787719727,2.520865201950073,2.786704301834106,2.800430059432983,2.480900287628174,1.991958618164062,1.800037622451782,2.193231582641602,3.039751052856445,3.943662643432617,4.320545196533203,4.105703830718994,3.745497465133667,3.358486890792847,2.913014888763428,2.513015270233154,2.164864540100098,1.770336627960205,1.575390100479126,1.703492403030396,1.84761643409729,1.711478233337402,1.412079334259033,1.232131719589233,1.141623258590698,1.177554130554199,1.475039720535278,1.872514486312866,2.081043720245361,2.065104246139526,1.874538660049438,1.479349136352539,0.903249979019165,0.1987302303314209,-0.337604284286499,-0.5995917320251465,-0.7066226005554199,-0.5436587333679199,-0.1446640491485596,0.02253413200378418,-0.13275146484375,-0.2879583835601807,-0.3842782974243164,-0.379561185836792,-0.2323508262634277,-0.152510404586792,-0.08908867835998535,0.1481759548187256,0.3993558883666992,0.4060864448547363,0.3335845470428467,0.295708179473877,0.3735959529876709,0.5806231498718262,0.7157385349273682,0.6324505805969238,0.4963588714599609,0.566486120223999,0.8259093761444092,1.035937070846558,1.046129465103149,0.9577345848083496,0.7576847076416016,0.3512227535247803,-0.2147698402404785,-0.7069015502929688,-1.108828783035278,-1.395896673202515,-1.301279067993164,-0.8143436908721924,-0.4536187648773193,-0.4479396343231201,-0.625079870223999,-0.8729267120361328,-1.232317686080933,-1.411657333374023,-1.225926876068115,-1.052302122116089,-1.057670116424561,-0.9340167045593262,-0.7010650634765625,-0.6212389469146729,-0.6459331512451172,-0.6448817253112793,-0.734027624130249,-0.768592357635498,-0.5543553829193115,-0.2960693836212158,-0.3432834148406982,-0.5224442481994629,-0.6446778774261475,-0.7296895980834961,-0.6660211086273193,-0.4324615001678467,-0.2891814708709717,-0.4756879806518555,-0.7292568683624268,-0.6862270832061768,-0.5350720882415771,-0.7533609867095947,-1.476520299911499,-2.242326736450195,-2.637737989425659,-2.661573886871338,-2.359524965286255,-1.844494342803955,-1.363706588745117,-1.116002798080444,-1.123065948486328,-1.397005319595337,-1.719685792922974,-1.888400316238403,-2.13659405708313,-2.518597841262817,-2.778654098510742,-2.807328701019287,-2.760590314865112,-2.724909782409668,-2.566527128219604,-2.43072509765625,-2.455304861068726,-2.502357959747314,-2.517768144607544,-2.510629892349243,-2.382034063339233,-2.189465761184692,-2.150784730911255,-2.019975185394287,-1.539198160171509,-1.032875776290894,-0.6481039524078369,-0.2027714252471924,0.1161718368530273,0.1113474369049072,0.07815957069396973,0.2739286422729492,0.609515905380249,0.8413660526275635,0.7711350917816162,0.5136358737945557,0.3139007091522217,0.2223408222198486,0.2405905723571777,0.4114079475402832,0.6824970245361328,0.8996701240539551,1.042381525039673,0.9971988201141357,0.7390844821929932,0.4497849941253662,0.207284688949585,-0.01430869102478027,-0.1023316383361816,-0.01440167427062988,-0.05074024200439453,-0.386052131652832,-0.6348216533660889,-0.3400504589080811,0.213857889175415,0.5441486835479736,0.6393849849700928,0.6064152717590332,0.3643584251403809,-0.06000638008117676,-0.2687180042266846,-0.004523992538452148,0.5165541172027588,0.8976387977600098,1.117962598800659,1.312140226364136,1.345925331115723,1.193432807922363,1.161178350448608,1.459118127822876,1.958402395248413,2.479405403137207,2.752865552902222,2.548649311065674,2.129749059677124,1.943010091781616,2.087166309356689,2.375553846359253,2.58718729019165,2.653824090957642,2.881218194961548,3.327341079711914,3.591302633285522,3.515946865081787,3.182920217514038,2.666044235229492,2.077771425247192,1.740331649780273,1.713953018188477,1.669217348098755,1.477446556091309,1.271753311157227,1.133970022201538,1.020097732543945,0.9263849258422852,0.9533679485321045,0.9585785865783691,0.7487225532531738,0.4822325706481934,0.3673231601715088,0.3428328037261963,0.2316033840179443,0.02764463424682617,-0.03021240234375,0.06030678749084473,0.09235024452209473,0.04666686058044434,0.06908655166625977,0.08859157562255859,-0.1174914836883545,-0.4892635345458984,-0.6709921360015869,-0.6088721752166748,-0.5915486812591553,-0.6175053119659424,-0.6321930885314941,-0.7431328296661377,-0.8467555046081543,-1.054844856262207,-1.52534008026123,-1.9547438621521,-2.080042362213135,-2.009457349777222,-1.81208610534668,-1.613219976425171,-1.424099206924438,-1.101804971694946,-0.8537077903747559,-0.8721649646759033,-0.9420669078826904,-0.7893097400665283,-0.6462264060974121,-0.8257699012756348,-0.9695076942443848,-0.9268820285797119,-0.9994518756866455,-1.174399852752686,-1.219189167022705,-1.322314739227295,-1.656056642532349,-1.922160387039185,-1.858706474304199,-1.47315502166748,-1.096293926239014,-0.9583175182342529,-1.021542549133301,-0.9965980052947998,-0.7578563690185547,-0.4106104373931885,-0.05981683731079102,0.2352547645568848,0.5019664764404297,0.6654882431030273,0.6137824058532715,0.5389809608459473,0.6785309314727783,0.8144724369049072,0.7000958919525146,0.5684709548950195,0.5255591869354248,0.4329121112823486,0.2455830574035645,0.1565086841583252,0.381159782409668,0.930100679397583,1.470919847488403,1.616907119750977,1.130776405334473,0.1937127113342285,-0.7507181167602539,-1.245989799499512,-1.165755987167358,-0.8184027671813965,-0.6121587753295898,-0.5743789672851562,-0.3734958171844482,0.1508224010467529,0.7877147197723389,1.17303729057312,1.01057767868042,0.5093801021575928,0.09581923484802246,0.008668899536132812,0.1868462562561035,0.4849398136138916,0.6690144538879395,0.5812346935272217,0.5751478672027588,0.7895243167877197,0.8256232738494873,0.6838560104370117,0.6840777397155762,0.687793493270874,0.4665398597717285,0.1964092254638672,0.05599379539489746,-0.03155350685119629,-0.2416098117828369,-0.3057396411895752,0.1614654064178467,0.8365774154663086,1.007487773895264,0.5513691902160645,-0.01485586166381836,-0.4442846775054932,-0.7455790042877197,-0.8831441402435303,-0.9225583076477051,-1.011196374893188,-0.9189963340759277,-0.6588292121887207,-0.7456111907958984,-1.279345750808716,-1.880085468292236,-2.382659912109375,-2.745137214660645,-2.71180272102356,-2.299618721008301,-1.820064783096313,-1.517475843429565,-1.33126974105835,-1.274864673614502,-1.434663534164429,-1.613134145736694,-1.443661451339722,-1.045997142791748,-0.9232378005981445,-0.877300500869751,-0.5762028694152832,-0.3701090812683105,-0.4882907867431641,-0.5625128746032715,-0.3429543972015381,-0.1468884944915771,0.04130959510803223,0.4028463363647461,0.7829976081848145,0.9590542316436768,1.00483775138855,1.175258159637451,1.571677923202515,2.109657526016235,2.643134593963623,3.126583099365234,3.324276208877563,3.100883960723877,2.660468816757202,2.190284729003906,1.955459117889404,2.12286114692688,2.301167249679565,2.154768705368042,1.958227157592773,1.92369818687439,1.777821779251099,1.449251174926758,0.9900498390197754,0.5264890193939209,0.3330695629119873,0.5476605892181396,0.9040045738220215,1.091659069061279,1.179717779159546,1.129206418991089,0.8709704875946045,0.5415880680084229,0.3793644905090332,0.3248941898345947,0.1407873630523682,-0.1728808879852295,-0.4717826843261719,-0.6924140453338623,-0.9931361675262451,-1.143540143966675,-0.7947635650634766,-0.3023850917816162,0.1343607902526855,0.7576668262481689,1.415369510650635,1.608384847640991,1.344870328903198,0.9674227237701416,0.6591796875,0.4075133800506592,0.3521668910980225,0.4144871234893799,0.4225659370422363,0.4191362857818604,0.3919351100921631,0.1748406887054443,-0.2841532230377197,-0.6668007373809814,-0.7485115528106689,-0.5622768402099609,-0.3240108489990234,-0.2299976348876953,-0.2194333076477051,-0.3005468845367432,-0.4904186725616455,-0.6464695930480957,-0.5992805957794189,-0.2788639068603516,0.2018415927886963,0.4788565635681152,0.47599196434021,0.6831014156341553,1.043121814727783,1.063982248306274,0.7609069347381592,0.49749970436]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>AR15</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"thresh"</value></param>
<param><key>size</key><value>1024*10</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>0.0</value></param>
<param><key>tr_level</key><value>.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"filter out"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>100.0</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"direct audio"</value></param>
<param><key>size</key><value>1024*200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>15</value></param>
<param><key>ymin</key><value>-15</value></param>
</block>
<connection><source_block_id>astra_xcorr_ts_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_delay_0_2</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_delay_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>astra_xcorr_ts_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
